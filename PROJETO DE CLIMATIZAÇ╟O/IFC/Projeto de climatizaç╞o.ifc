Properties of the parts of a building model (IFC2X3), part 1 of 5

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: f85f8cc5-4536-4adb-a5d9-5d9513bde02f, NumberOfSaves: 197], CoordinateReference [CoordinateBase: Coordenadas compartilhadas]
File name: Projeto de climatização.ifc
Time: 2026-09-07T14:08:48-03:00
Written by: ODA SDAI 24.11
Made in: Autodesk Revit 25.0.2.419 (PTB) - IFC 25.0.2.419

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2

# IfcBuildingStorey: Nível:Cabeça de 8 mm (2)
Name | LongName | Elevation (mm)
Nível 1 | Nível 1 | 0
Nível 2 | Nível 2 | 3880

# IfcBuildingElementProxy: FH:FH 200 (2)
In: Nível 1
Type - Material: Steel, Galvanized White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Siclfux
Pset_BuildingElementProxyCommon - Reference: FH 200; sets with these values: 2
Name (FH:FH 200:...) | Group
1001962 | Mecânica Ar de fornecimento 11
1002109 | Mecânica Ar de fornecimento 12

# IfcBuildingElementProxy: FH:FH 355 (4)
In: Nível 1
Type - Material: Steel, Galvanized White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Siclfux
Pset_BuildingElementProxyCommon - Reference: FH 355; sets with these values: 2
Name (FH:FH 355:...) | Group
998391 | Mecânica Ar de fornecimento 3
998609 | Mecânica Ar de fornecimento 4
1001023 | Mecânica Ar de fornecimento 9
1001305 | Mecânica Ar de fornecimento 10

# IfcBuildingElementProxy: FH:FH 400 (10)
Type - Material: Steel, Galvanized White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Siclfux
Pset_BuildingElementProxyCommon - Reference: FH 400; sets with these values: 2
Name (FH:FH 400:...) | In | Group
995763 | Nível 1 | Mecânica Ar de fornecimento 1
995770 | Nível 1 | Mecânica Ar de fornecimento 1
995993 | Nível 1 | Mecânica Ar de fornecimento 3
996059 | Nível 1 | Mecânica Ar de fornecimento 4
1003087 | Nível 2 | Mecânica Ar de fornecimento 14
1003094 | Nível 2 | Mecânica Ar de fornecimento 13
1003878 | Nível 2 | Mecânica Ar de fornecimento 13
1004700 | Nível 2 | Mecânica Ar de fornecimento 14
1006605 | Nível 2 | Mecânica Ar de fornecimento 14
1007177 | Nível 2 | Mecânica Ar de fornecimento 17

# IfcBuildingElementProxy: Família V8_220V:Tp33 72 HP, Família V8_220V:Tp33 72 HP:1099804
In: Nível 2
Type - Material: Aço. acabamento pintado. azul, Aço. acabamento pintado. vermelho, Aço galvanizado pintado, CG Branco, Midea White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Springer
Material: Midea White, <Unnamed>, White, Galvanized Steel, Aço. acabamento pintado. azul, Dark Blue; Group: Fornecimento hidrônico 2; Outros 3
Pset_BuildingElementProxyCommon - Reference: Tp33 72 HP; sets with these values: 2

# IfcBuildingElementProxy: Família V8_220V:Tp41 88 HP, Família V8_220V:Tp41 88 HP:1103473
In: Nível 2
Type - Material: Aço. acabamento pintado. azul, Aço. acabamento pintado. vermelho, Aço galvanizado pintado, CG Branco
Type - Pset_ManufacturerTypeInformation - Manufacturer: Springer
Material: <Unnamed>, White, Aço. acabamento pintado. azul, Galvanized Steel, Dark Blue, Midea White; Group: Outros 4; Retorno hidrônico 1
Pset_BuildingElementProxyCommon - Reference: Tp41 88 HP; sets with these values: 2

# IfcBuildingElementProxy: Midea_VRF_Indoor_4-way Cassette_MI-56(71,80)Q4_DHN1-D (2nd DC):MI2-71Q4DHN1 (9)
Type - Material: grilles：ABS/HIPS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Midea
Pset_BuildingElementProxyCommon - Reference: MI2-71Q4DHN1; sets with these values: 2
Name (Midea_VRF_Indoor_4-way Cassette_MI-56(71,80)Q4_DHN1-D (2nd DC):MI2-71Q4DHN1:...) | In | Group
1086562 | Nível 1 | Outros 2; Fornecimento hidrônico 2; Fornecimento hidrônico 3
1086573 | Nível 1 | Outros 2; Fornecimento hidrônico 2; Fornecimento hidrônico 4
1086865 | Nível 1 | Fornecimento hidrônico 2; Fornecimento hidrônico 1; Fornecimento hidrônico 8
1103197 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 36
1103276 | Nível 2 | Outros 6; Fornecimento hidrônico 40; Outros 8
1103287 | Nível 2 | Outros 6; Outros 8; Fornecimento hidrônico 41
1103298 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 39
1103341 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 44
1103384 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 47

# IfcBuildingElementProxy: Midea_VRF_Indoor_4-way Cassette_MI-90(100,112,140)Q4_DHN1-D (2nd DC):MI2-100Q4DHN1 (18)
Type - Material: grilles：ABS/HIPS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Midea
Pset_BuildingElementProxyCommon - Reference: MI2-100Q4DHN1; sets with these values: 2
Name (Midea_VRF_Indoor_4-way Cassette_MI-90(100,112,140)Q4_DHN1-D (2nd DC):MI2-100Q4DHN1:...) | In | Group
1086545 | Nível 1 | Fornecimento hidrônico 5; Outros 2; Fornecimento hidrônico 2
1086634 | Nível 1 | Fornecimento hidrônico 2; Fornecimento hidrônico 1; Fornecimento hidrônico 9
1086645 | Nível 1 | Fornecimento hidrônico 2; Fornecimento hidrônico 1; Fornecimento hidrônico 12
1086656 | Nível 1 | Fornecimento hidrônico 2; Fornecimento hidrônico 1; Fornecimento hidrônico 6
1086667 | Nível 1 | Fornecimento hidrônico 2; Fornecimento hidrônico 1; Fornecimento hidrônico 11
1086678 | Nível 1 | Fornecimento hidrônico 2; Fornecimento hidrônico 1; Fornecimento hidrônico 13
1102725 | Nível 2 | Fornecimento hidrônico 23; Outros 5; Outros 6
1102736 | Nível 2 | Outros 5; Outros 6; Fornecimento hidrônico 22
1102912 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 45
1102923 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 46
1103214 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 29
1103229 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 32
1103244 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 31
1103255 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 30
1103312 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 37
1103323 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 38
1103355 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 42
1103370 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 43

# IfcBuildingElementProxy: Midea_VRF_Indoor_4-way Cassette_MI-90(100,112,140)Q4_DHN1-D (2nd DC):MI2-112Q4DHN1 (11)
Type - Material: grilles：ABS/HIPS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Midea
Pset_BuildingElementProxyCommon - Reference: MI2-112Q4DHN1; sets with these values: 2
Name (Midea_VRF_Indoor_4-way Cassette_MI-90(100,112,140)Q4_DHN1-D (2nd DC):MI2-112Q4DHN1:...) | In | Group
1086598 | Nível 1 | Fornecimento hidrônico 2; Fornecimento hidrônico 17; Fornecimento hidrônico 1
1086609 | Nível 1 | Fornecimento hidrônico 2; Fornecimento hidrônico 1; Fornecimento hidrônico 18
1086689 | Nível 1 | Fornecimento hidrônico 1; Fornecimento hidrônico 20
1086700 | Nível 1 | Fornecimento hidrônico 1; Fornecimento hidrônico 14
1086715 | Nível 1 | Fornecimento hidrônico 1; Fornecimento hidrônico 21
1086726 | Nível 1 | Fornecimento hidrônico 1; Fornecimento hidrônico 15
1086804 | Nível 1 | Fornecimento hidrônico 2; Fornecimento hidrônico 1; Fornecimento hidrônico 7
1086851 | Nível 1 | Fornecimento hidrônico 2; Fornecimento hidrônico 1; Fornecimento hidrônico 16
1102937 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 35
1103167 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 34
1103181 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 33

# IfcBuildingElementProxy: Midea_VRF_Indoor_4-way Cassette_MI-90(100,112,140)Q4_DHN1-D (2nd DC):MI2-140Q4DHN1 (7)
Type - Material: grilles：ABS/HIPS
Type - Pset_ManufacturerTypeInformation - Manufacturer: Midea
Pset_BuildingElementProxyCommon - Reference: MI2-140Q4DHN1; sets with these values: 2
Name (Midea_VRF_Indoor_4-way Cassette_MI-90(100,112,140)Q4_DHN1-D (2nd DC):MI2-140Q4DHN1:...) | In | Group
1086620 | Nível 1 | Outros 2; Fornecimento hidrônico 2; Fornecimento hidrônico 10
1086822 | Nível 1 | Fornecimento hidrônico 2; Fornecimento hidrônico 1; Fornecimento hidrônico 19
1102747 | Nível 2 | Outros 6; Fornecimento hidrônico 24; Outros 4
1102847 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 25
1102862 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 28
1102865 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 27
1102868 | Nível 2 | Outros 6; Outros 4; Fornecimento hidrônico 26

# IfcDistributionPort (3613)
Description: Flow
Name | FlowDirection | Group
InPort_996073_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_995763_1 | SOURCE | Mecânica Ar de fornecimento 1
InPort_995763_2 | SINK | Mecânica Ar de fornecimento 1
OutPort_996326_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_995796_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_995770_1 | SOURCE | Mecânica Ar de fornecimento 1
InPort_995770_2 | SINK | Mecânica Ar de fornecimento 1
OutPort_996354_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_995796_1 | SINK | Mecânica Ar de fornecimento 1
InPort_997988_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_995796_2 | SOURCE | Mecânica Ar de fornecimento 1
InPort_995796_4 | SINK | Mecânica Ar de fornecimento 1
OutPort_998011_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_995796_5 | SINK | Mecânica Ar de fornecimento 1
OutPort_998018_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_995796_6 | SINK | Mecânica Ar de fornecimento 1
OutPort_998037_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_995796_7 | SINK | Mecânica Ar de fornecimento 1
OutPort_998048_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_995993_1 | SINK | Mecânica Ar de fornecimento 3
OutPort_996113_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_996167_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_995993_2 | SOURCE | Mecânica Ar de fornecimento 3
InPort_996059_1 | SINK | Mecânica Ar de fornecimento 4
OutPort_996141_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_996294_0 | SINK | Mecânica Ar de fornecimento 4
OutPort_996059_2 | SOURCE | Mecânica Ar de fornecimento 4
InPort_996073_1 | SINK | Mecânica Ar de fornecimento 1
InPort_996073_2 | SINK | Mecânica Ar de fornecimento 1
OutPort_998071_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_996073_3 | SINK | Mecânica Ar de fornecimento 1
OutPort_998086_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998116_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_996073_5 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998127_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_996073_6 | SOURCE | Mecânica Ar de fornecimento 1
OutPort_996113_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_996113_2 | SINK | Mecânica Ar de fornecimento 3
OutPort_998215_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998237_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_996113_4 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998248_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_996113_5 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998259_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_996113_6 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998274_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_996113_7 | SOURCE | Mecânica Ar de fornecimento 3
OutPort_996141_1 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998297_0 | SINK | Mecânica Ar de fornecimento 4
OutPort_996141_2 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998312_0 | SINK | Mecânica Ar de fornecimento 4
OutPort_996141_3 | SOURCE | Mecânica Ar de fornecimento 4
InPort_996141_5 | SINK | Mecânica Ar de fornecimento 4
OutPort_998342_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_996141_7 | SINK | Mecânica Ar de fornecimento 4
OutPort_998364_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_1003032_2 | SINK | Mecânica Ar de fornecimento 3
OutPort_996167_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_999050_1 | SINK | Mecânica Ar de fornecimento 3
OutPort_996167_2 | SOURCE | Mecânica Ar de fornecimento 3
OutPort_996294_1 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998821_1 | SINK | Mecânica Ar de fornecimento 4
OutPort_996294_2 | SOURCE | Mecânica Ar de fornecimento 4
InPort_996326_1 | SINK | Mecânica Ar de fornecimento 1
InPort_996326_2 | SINK | Mecânica Ar de fornecimento 1
OutPort_996381_1 | SOURCE | Mecânica Ar de fornecimento 1
InPort_996354_1 | SINK | Mecânica Ar de fornecimento 1
OutPort_996384_2 | SOURCE | Mecânica Ar de fornecimento 1
InPort_996368_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_996381_2 | SOURCE | Mecânica Ar de fornecimento 1
InPort_996384_1 | SINK | Mecânica Ar de fornecimento 1
OutPort_996368_1 | SOURCE | Mecânica Ar de fornecimento 1
InPort_996381_1 | SINK | Mecânica Ar de fornecimento 1
OutPort_996326_2 | SOURCE | Mecânica Ar de fornecimento 1
InPort_997985_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_997987_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_997987_1 | SINK | Mecânica Ar de fornecimento 1
OutPort_997988_1 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998008_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_998010_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998010_1 | SINK | Mecânica Ar de fornecimento 1
OutPort_998011_1 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998011_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_995796_4 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998015_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_998017_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998017_1 | SINK | Mecânica Ar de fornecimento 1
OutPort_998018_1 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998018_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_995796_5 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998036_0 | SINK | Mecânica Ar de fornecimento 1
InPort_998037_1 | SINK | Mecânica Ar de fornecimento 1
OutPort_998036_1 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998045_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_998047_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998047_1 | SINK | Mecânica Ar de fornecimento 1
OutPort_998048_1 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998048_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_995796_7 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998068_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_998070_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998070_1 | SINK | Mecânica Ar de fornecimento 1
OutPort_998071_1 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998071_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_996073_2 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998083_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_998085_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998085_1 | SINK | Mecânica Ar de fornecimento 1
OutPort_998086_1 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998086_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_996073_3 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998113_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_998115_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998115_1 | SINK | Mecânica Ar de fornecimento 1
OutPort_998116_1 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998124_0 | SINK | Mecânica Ar de fornecimento 1
OutPort_998126_0 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998126_1 | SINK | Mecânica Ar de fornecimento 1
OutPort_998127_1 | SOURCE | Mecânica Ar de fornecimento 1
InPort_998214_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_998212_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998215_1 | SINK | Mecânica Ar de fornecimento 3
OutPort_998214_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998236_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_998234_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998237_1 | SINK | Mecânica Ar de fornecimento 3
OutPort_998236_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_996113_4 | SINK | Mecânica Ar de fornecimento 3
OutPort_998237_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998247_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_998245_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998248_1 | SINK | Mecânica Ar de fornecimento 3
OutPort_998247_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_996113_5 | SINK | Mecânica Ar de fornecimento 3
OutPort_998248_0 | SOURCE | Mecânica Ar de fornecimento 3
OutPort_998258_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998258_1 | SINK | Mecânica Ar de fornecimento 3
OutPort_998259_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998273_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_998271_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998274_1 | SINK | Mecânica Ar de fornecimento 3
OutPort_998273_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_996113_7 | SINK | Mecânica Ar de fornecimento 3
OutPort_998274_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998296_0 | SINK | Mecânica Ar de fornecimento 4
OutPort_998294_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998297_1 | SINK | Mecânica Ar de fornecimento 4
OutPort_998296_1 | SOURCE | Mecânica Ar de fornecimento 4
InPort_996141_2 | SINK | Mecânica Ar de fornecimento 4
OutPort_998297_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998311_0 | SINK | Mecânica Ar de fornecimento 4
OutPort_998309_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998312_1 | SINK | Mecânica Ar de fornecimento 4
OutPort_998311_1 | SOURCE | Mecânica Ar de fornecimento 4
InPort_996141_3 | SINK | Mecânica Ar de fornecimento 4
OutPort_998312_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998341_0 | SINK | Mecânica Ar de fornecimento 4
OutPort_998339_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998342_1 | SINK | Mecânica Ar de fornecimento 4
OutPort_998341_1 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998363_0 | SINK | Mecânica Ar de fornecimento 4
OutPort_998361_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998364_1 | SINK | Mecânica Ar de fornecimento 4
OutPort_998363_1 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998515_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_998391_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998391_2 | SINK | Mecânica Ar de fornecimento 3
OutPort_998495_0 | SOURCE | Mecânica Ar de fornecimento 3
OutPort_998495_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998495_2 | SINK | Mecânica Ar de fornecimento 3
OutPort_998962_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998974_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_998495_3 | SOURCE | Mecânica Ar de fornecimento 3
InPort_999053_1 | SINK | Mecânica Ar de fornecimento 3
OutPort_998515_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998609_1 | SINK | Mecânica Ar de fornecimento 4
OutPort_998860_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998745_0 | SINK | Mecânica Ar de fornecimento 4
OutPort_998609_2 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998824_2 | SINK | Mecânica Ar de fornecimento 4
OutPort_998745_1 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998821_2 | SINK | Mecânica Ar de fornecimento 4
OutPort_998809_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998809_1 | SINK | Mecânica Ar de fornecimento 4
OutPort_998824_1 | SOURCE | Mecânica Ar de fornecimento 4
InPort_996294_2 | SINK | Mecânica Ar de fornecimento 4
OutPort_998821_1 | SOURCE | Mecânica Ar de fornecimento 4
OutPort_998860_1 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998993_0 | SINK | Mecânica Ar de fornecimento 4
OutPort_998860_2 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998860_3 | SINK | Mecânica Ar de fornecimento 4
OutPort_999008_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998961_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_998959_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998962_1 | SINK | Mecânica Ar de fornecimento 3
OutPort_998961_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998973_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_998971_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998974_1 | SINK | Mecânica Ar de fornecimento 3
OutPort_998973_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998495_3 | SINK | Mecânica Ar de fornecimento 3
OutPort_998974_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_998992_0 | SINK | Mecânica Ar de fornecimento 4
OutPort_998990_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998993_1 | SINK | Mecânica Ar de fornecimento 4
OutPort_998992_1 | SOURCE | Mecânica Ar de fornecimento 4
InPort_998860_2 | SINK | Mecânica Ar de fornecimento 4
OutPort_998993_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_999007_0 | SINK | Mecânica Ar de fornecimento 4
OutPort_999005_0 | SOURCE | Mecânica Ar de fornecimento 4
InPort_999008_1 | SINK | Mecânica Ar de fornecimento 4
OutPort_999007_1 | SOURCE | Mecânica Ar de fornecimento 4
InPort_999050_2 | SINK | Mecânica Ar de fornecimento 3
OutPort_999038_0 | SOURCE | Mecânica Ar de fornecimento 3
InPort_999038_1 | SINK | Mecânica Ar de fornecimento 3
OutPort_999053_2 | SOURCE | Mecânica Ar de fornecimento 3
InPort_996167_2 | SINK | Mecânica Ar de fornecimento 3
OutPort_999050_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_1001279_0 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001023_1 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001023_2 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001097_0 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001097_1 | SINK | Mecânica Ar de fornecimento 9
InPort_1001279_1 | SINK | Mecânica Ar de fornecimento 9
InPort_1001691_1 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001279_2 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001279_3 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001709_1 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001279_4 | SINK | Mecânica Ar de fornecimento 9
OutPort_1102711_1 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001305_1 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001584_0 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001355_0 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001305_2 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001490_2 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001355_1 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001482_0 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001490_1 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001577_1 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001482_1 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001567_0 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001577_2 | SOURCE | Mecânica Ar de fornecimento 10
OutPort_1001567_1 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001658_2 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001584_1 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001584_2 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001828_0 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001835_0 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001584_3 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001648_0 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001658_1 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001668_1 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001648_1 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001660_0 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001668_2 | SOURCE | Mecânica Ar de fornecimento 10
OutPort_1001660_1 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001850_0 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001660_2 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001683_0 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001691_2 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001683_1 | SINK | Mecânica Ar de fornecimento 9
InPort_1001904_0 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001683_2 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001701_0 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001709_2 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001701_1 | SINK | Mecânica Ar de fornecimento 9
InPort_1001919_0 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001701_2 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001709_1 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001279_3 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001718_0 | SINK | Mecânica Ar de fornecimento 9
OutPort_1102711_2 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001718_1 | SINK | Mecânica Ar de fornecimento 9
InPort_1001938_0 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001718_2 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001827_0 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001825_0 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001828_1 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001827_1 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001834_0 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001832_0 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001835_1 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001834_1 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001584_3 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001835_0 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001849_0 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001847_0 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001850_1 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001849_1 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001660_2 | SINK | Mecânica Ar de fornecimento 10
OutPort_1001850_0 | SOURCE | Mecânica Ar de fornecimento 10
InPort_1001901_0 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001903_0 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001903_1 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001904_1 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001916_0 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001918_0 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001918_1 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001919_1 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001935_0 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001937_0 | SOURCE | Mecânica Ar de fornecimento 9
InPort_1001937_1 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001938_1 | SOURCE | Mecânica Ar de fornecimento 9
Port_1001962_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125073_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1001962_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002007_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125073_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002007_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002028_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002019_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002028_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002019_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002047_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002047_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002047_8 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125082_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002047_9 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125089_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002047_10 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125092_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002109_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1127467_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002109_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1125054_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002200_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1127467_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002200_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002259_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002249_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002259_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002249_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002269_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002261_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002269_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002261_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002283_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1125054_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002283_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002299_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002283_4 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1125062_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002293_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002299_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002293_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002311_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002301_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002311_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002301_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002301_6 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1127469_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002301_7 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1127472_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002329_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125089_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002329_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002329_3 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125091_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002354_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125082_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002354_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002354_3 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125084_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002405_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125092_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002405_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002405_3 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125094_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002425_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1127469_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002425_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002425_3 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1127471_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002443_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1127472_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002443_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002443_3 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1127474_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002462_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1125062_2 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002462_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002462_3 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1125065_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002486_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002488_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002488_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1125065_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002505_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002507_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002507_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1127474_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002516_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002518_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002518_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1127471_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 12
Port_1002547_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002549_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002549_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125094_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002562_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002564_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002564_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125091_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002581_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002583_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1002583_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
Port_1125084_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 11
InPort_1003022_0 | SINK | Mecânica Ar de fornecimento 3
OutPort_1003032_1 | SOURCE | Mecânica Ar de fornecimento 3
OutPort_1003022_1 | SOURCE | Mecânica Ar de fornecimento 3
InPort_1003087_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003312_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003286_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003087_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003094_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003216_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003260_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003094_2 | SOURCE | Mecânica Ar de fornecimento 13
Port_1003216_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 13
Port_1007434_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 13
InPort_1003216_3 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003427_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003500_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003216_4 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003527_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003216_5 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003260_1 | SINK | Mecânica Ar de fornecimento 13
InPort_1085417_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003260_2 | SOURCE | Mecânica Ar de fornecimento 13
OutPort_1003286_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003312_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003332_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003332_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003324_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003324_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003340_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003340_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003334_0 | SOURCE | Mecânica Ar de fornecimento 14
Port_1003334_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 14
Port_1007442_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 14
InPort_1003334_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003817_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003334_3 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003846_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003334_4 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003861_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003427_2 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003416_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003416_1 | SINK | Mecânica Ar de fornecimento 13
InPort_1003416_2 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003577_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003498_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003500_2 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003498_1 | SINK | Mecânica Ar de fornecimento 13
InPort_1003615_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003498_2 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003525_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003527_2 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003525_1 | SINK | Mecânica Ar de fornecimento 13
InPort_1003634_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003525_2 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003574_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003576_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003576_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003577_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003577_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003416_2 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003612_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003614_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003614_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003615_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003631_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003633_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003633_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003634_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003816_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003814_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003817_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003816_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003845_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003843_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003846_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003845_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003860_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003858_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1003861_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1003860_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1004301_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1003878_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1003878_2 | SINK | Mecânica Ar de fornecimento 13
OutPort_1005187_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004474_2 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004301_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004358_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004438_1 | SOURCE | Mecânica Ar de fornecimento 13
Port_1004358_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 13
Port_1007426_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 13
InPort_1004474_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004358_2 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004661_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004358_3 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004676_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004358_4 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004691_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004358_5 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004438_2 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004428_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004428_1 | SINK | Mecânica Ar de fornecimento 13
InPort_1004428_2 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004616_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004358_2 | SINK | Mecânica Ar de fornecimento 15
OutPort_1004474_1 | SOURCE | Mecânica Ar de fornecimento 15
InPort_1004613_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004615_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004615_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004616_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004616_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004428_2 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004658_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004660_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004660_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004661_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004673_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004675_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004675_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004676_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004688_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004690_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004690_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1004691_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1004700_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1004754_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006169_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1004700_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1004754_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006062_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1005187_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1005258_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1005258_2 | SINK | Mecânica Ar de fornecimento 13
OutPort_1005201_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1005201_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1085399_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1005293_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006459_2 | SOURCE | Mecânica Ar de fornecimento 14
OutPort_1005293_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006240_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005293_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006272_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005293_3 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006459_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005299_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1005299_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005348_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1005299_2 | SINK | Mecânica Ar de fornecimento 17
OutPort_1006085_1 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1005299_3 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006231_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1005353_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005335_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1005335_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005772_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1005348_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005346_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1005346_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005353_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1005776_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005761_0 | SOURCE | Mecânica Ar de fornecimento 14
Port_1005761_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 14
Port_1007417_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 14
InPort_1005761_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005941_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1005772_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005770_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1005770_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005776_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1005940_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005938_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1005941_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005940_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006062_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006087_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006077_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006085_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006087_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006077_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006085_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1005299_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007371_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006169_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1082582_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006169_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006230_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006228_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006231_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006230_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006239_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006237_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006240_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006239_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1005293_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006240_0 | SOURCE | Mecânica Ar de fornecimento 14
OutPort_1006272_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006605_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006842_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006635_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006605_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006655_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006635_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006649_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006655_2 | SOURCE | Mecânica Ar de fornecimento 14
OutPort_1006649_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007552_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006649_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007569_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006649_3 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007720_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006649_4 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007821_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1006649_6 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006842_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1082582_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007177_1 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007229_0 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007248_0 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007177_2 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007229_1 | SINK | Mecânica Ar de fornecimento 17
OutPort_1045534_2 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007264_1 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007248_1 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007258_0 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007264_2 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007258_1 | SINK | Mecânica Ar de fornecimento 17
InPort_1007258_2 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007465_0 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007474_0 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007258_3 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007258_6 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007845_1 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007358_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007371_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007379_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007358_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007373_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007379_1 | SOURCE | Mecânica Ar de fornecimento 14
OutPort_1007373_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007462_0 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007464_0 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007464_1 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007465_1 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007465_0 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007258_2 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007471_0 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007473_0 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007473_1 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007474_1 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007552_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007544_0 | SOURCE | Mecânica Ar de fornecimento 14
OutPort_1007544_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007544_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007606_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006649_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007552_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007561_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007569_2 | SOURCE | Mecânica Ar de fornecimento 14
OutPort_1007561_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007621_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007561_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007605_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007603_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007606_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007605_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007620_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007618_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007621_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007620_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007561_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007621_0 | SOURCE | Mecânica Ar de fornecimento 14
OutPort_1007720_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007821_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007813_0 | SOURCE | Mecânica Ar de fornecimento 14
OutPort_1007813_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1008038_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007813_2 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007813_3 | SINK | Mecânica Ar de fornecimento 14
OutPort_1008063_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1006649_6 | SINK | Mecânica Ar de fornecimento 14
OutPort_1007821_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1007845_2 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007837_0 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007837_1 | SINK | Mecânica Ar de fornecimento 17
InPort_1007837_2 | SINK | Mecânica Ar de fornecimento 17
OutPort_1008023_0 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1007837_3 | SINK | Mecânica Ar de fornecimento 17
OutPort_1008124_0 | SOURCE | Mecânica Ar de fornecimento 17
Port_1008020_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 17
Port_1008022_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 17
Port_1008022_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 17
Port_1008023_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 17
Port_1008035_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 14
Port_1008037_0 | SOURCEANDSINK | Mecânica Ar de fornecimento 14
Port_1008037_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 14
Port_1008038_1 | SOURCEANDSINK | Mecânica Ar de fornecimento 14
InPort_1008063_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1008055_0 | SOURCE | Mecânica Ar de fornecimento 14
OutPort_1008055_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1008055_2 | SINK | Mecânica Ar de fornecimento 14
OutPort_1008086_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1008085_0 | SINK | Mecânica Ar de fornecimento 14
OutPort_1008083_0 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1008086_1 | SINK | Mecânica Ar de fornecimento 14
OutPort_1008085_1 | SOURCE | Mecânica Ar de fornecimento 14
InPort_1008121_0 | SINK | Mecânica Ar de fornecimento 17
OutPort_1008123_0 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1008123_1 | SINK | Mecânica Ar de fornecimento 17
OutPort_1008124_1 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1008124_0 | SINK | Mecânica Ar de fornecimento 17
OutPort_1007837_3 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1045534_1 | SINK | Mecânica Ar de fornecimento 17
OutPort_1045528_0 | SOURCE | Mecânica Ar de fornecimento 17
InPort_1045528_1 | SINK | Mecânica Ar de fornecimento 17
InPort_1085381_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1085423_2 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1085427_2 | SINK | Mecânica Ar de fornecimento 13
OutPort_1085381_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1085399_2 | SINK | Mecânica Ar de fornecimento 13
OutPort_1085397_0 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1085397_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1085427_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1085413_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1085417_2 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1085419_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1085413_1 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1085414_0 | SINK | Mecânica Ar de fornecimento 13
OutPort_1085419_2 | SOURCE | Mecânica Ar de fornecimento 13
InPort_1085423_1 | SINK | Mecânica Ar de fornecimento 13
OutPort_1085414_1 | SOURCE | Mecânica Ar de fornecimento 13
Port_1086545_5 | SOURCEANDSINK | Fornecimento hidrônico 5
Port_1119447_0 | SOURCEANDSINK | Fornecimento hidrônico 5
InPort_1087833_2 | SINK | Outros 2
OutPort_1086545_6 | SOURCE | Outros 2
InPort_1087856_1 | SINK | Fornecimento hidrônico 2
OutPort_1086545_7 | SOURCE | Fornecimento hidrônico 2
Port_1086545_8 | SOURCEANDSINK
Port_1086562_5 | SOURCEANDSINK | Fornecimento hidrônico 3
Port_1119496_0 | SOURCEANDSINK | Fornecimento hidrônico 3
InPort_1087650_1 | SINK | Outros 2
OutPort_1086562_6 | SOURCE | Outros 2
InPort_1087996_0 | SINK | Fornecimento hidrônico 2
OutPort_1086562_7 | SOURCE | Fornecimento hidrônico 2
Port_1086562_8 | SOURCEANDSINK
Port_1086573_5 | SOURCEANDSINK | Fornecimento hidrônico 4
Port_1119428_0 | SOURCEANDSINK | Fornecimento hidrônico 4
InPort_1088224_1 | SINK | Outros 2
OutPort_1086573_6 | SOURCE | Outros 2
InPort_1088422_1 | SINK | Fornecimento hidrônico 2
OutPort_1086573_7 | SOURCE | Fornecimento hidrônico 2
Port_1086573_8 | SOURCEANDSINK
Port_1086598_5 | SOURCEANDSINK | Fornecimento hidrônico 17
Port_1120633_0 | SOURCEANDSINK | Fornecimento hidrônico 17
InPort_1092379_1 | SINK | Fornecimento hidrônico 1
OutPort_1086598_6 | SOURCE | Fornecimento hidrônico 1
InPort_1092498_1 | SINK | Fornecimento hidrônico 2
OutPort_1086598_7 | SOURCE | Fornecimento hidrônico 2
Port_1086598_8 | SOURCEANDSINK
Port_1086609_5 | SOURCEANDSINK | Fornecimento hidrônico 18
Port_1120645_0 | SOURCEANDSINK | Fornecimento hidrônico 18
InPort_1092457_1 | SINK | Fornecimento hidrônico 1
OutPort_1086609_6 | SOURCE | Fornecimento hidrônico 1
InPort_1092576_1 | SINK | Fornecimento hidrônico 2
OutPort_1086609_7 | SOURCE | Fornecimento hidrônico 2
Port_1086609_8 | SOURCEANDSINK
Port_1086620_5 | SOURCEANDSINK | Fornecimento hidrônico 10
Port_1119904_0 | SOURCEANDSINK | Fornecimento hidrônico 10
InPort_1088314_1 | SINK | Outros 2
OutPort_1086620_6 | SOURCE | Outros 2
InPort_1088478_1 | SINK | Fornecimento hidrônico 2
OutPort_1086620_7 | SOURCE | Fornecimento hidrônico 2
Port_1086620_8 | SOURCEANDSINK
Port_1086634_5 | SOURCEANDSINK | Fornecimento hidrônico 9
Port_1120285_0 | SOURCEANDSINK | Fornecimento hidrônico 9
InPort_1090188_0 | SINK | Fornecimento hidrônico 1
OutPort_1086634_6 | SOURCE | Fornecimento hidrônico 1
InPort_1090290_1 | SINK | Fornecimento hidrônico 2
OutPort_1086634_7 | SOURCE | Fornecimento hidrônico 2
Port_1086634_8 | SOURCEANDSINK
Port_1086645_5 | SOURCEANDSINK | Fornecimento hidrônico 12
Port_1120061_0 | SOURCEANDSINK | Fornecimento hidrônico 12
InPort_1090331_1 | SINK | Fornecimento hidrônico 1
OutPort_1086645_6 | SOURCE | Fornecimento hidrônico 1
InPort_1090533_1 | SINK | Fornecimento hidrônico 2
OutPort_1086645_7 | SOURCE | Fornecimento hidrônico 2
Port_1086645_8 | SOURCEANDSINK
Port_1086656_5 | SOURCEANDSINK | Fornecimento hidrônico 6
Port_1119663_0 | SOURCEANDSINK | Fornecimento hidrônico 6
InPort_1090380_1 | SINK | Fornecimento hidrônico 1
OutPort_1086656_6 | SOURCE | Fornecimento hidrônico 1
InPort_1090485_1 | SINK | Fornecimento hidrônico 2
OutPort_1086656_7 | SOURCE | Fornecimento hidrônico 2
Port_1086656_8 | SOURCEANDSINK
Port_1086667_5 | SOURCEANDSINK | Fornecimento hidrônico 11
Port_1119996_0 | SOURCEANDSINK | Fornecimento hidrônico 11
InPort_1091378_0 | SINK | Fornecimento hidrônico 1
OutPort_1086667_6 | SOURCE | Fornecimento hidrônico 1
InPort_1091517_1 | SINK | Fornecimento hidrônico 2
OutPort_1086667_7 | SOURCE | Fornecimento hidrônico 2
Port_1086667_8 | SOURCEANDSINK
Port_1086678_5 | SOURCEANDSINK | Fornecimento hidrônico 13
Port_1120273_0 | SOURCEANDSINK | Fornecimento hidrônico 13
InPort_1091050_0 | SINK | Fornecimento hidrônico 1
OutPort_1086678_6 | SOURCE | Fornecimento hidrônico 1
InPort_1091249_1 | SINK | Fornecimento hidrônico 2
OutPort_1086678_7 | SOURCE | Fornecimento hidrônico 2
Port_1086678_8 | SOURCEANDSINK
Port_1086689_5 | SOURCEANDSINK | Fornecimento hidrônico 20
Port_1120963_0 | SOURCEANDSINK | Fornecimento hidrônico 20
InPort_1095104_1 | SINK | Fornecimento hidrônico 1
OutPort_1086689_6 | SOURCE | Fornecimento hidrônico 1
InPort_1095217_1 | SINK | Fornecimento hidrônico 1
OutPort_1086689_7 | SOURCE | Fornecimento hidrônico 1
Port_1086689_8 | SOURCEANDSINK
Port_1086700_5 | SOURCEANDSINK | Fornecimento hidrônico 14
Port_1120481_0 | SOURCEANDSINK | Fornecimento hidrônico 14
InPort_1095178_1 | SINK | Fornecimento hidrônico 1
OutPort_1086700_6 | SOURCE | Fornecimento hidrônico 1
InPort_1095267_1 | SINK | Fornecimento hidrônico 1
OutPort_1086700_7 | SOURCE | Fornecimento hidrônico 1
Port_1086700_8 | SOURCEANDSINK
Port_1086715_5 | SOURCEANDSINK | Fornecimento hidrônico 21
Port_1121035_0 | SOURCEANDSINK | Fornecimento hidrônico 21
InPort_1095408_1 | SINK | Fornecimento hidrônico 1
OutPort_1086715_6 | SOURCE | Fornecimento hidrônico 1
InPort_1095516_1 | SINK | Fornecimento hidrônico 1
OutPort_1086715_7 | SOURCE | Fornecimento hidrônico 1
Port_1086715_8 | SOURCEANDSINK
Port_1086726_5 | SOURCEANDSINK | Fornecimento hidrônico 15
Port_1120499_0 | SOURCEANDSINK | Fornecimento hidrônico 15
InPort_1095306_1 | SINK | Fornecimento hidrônico 1
OutPort_1086726_6 | SOURCE | Fornecimento hidrônico 1
InPort_1095458_1 | SINK | Fornecimento hidrônico 1
OutPort_1086726_7 | SOURCE | Fornecimento hidrônico 1
Port_1086726_8 | SOURCEANDSINK
Port_1086804_5 | SOURCEANDSINK | Fornecimento hidrônico 7
Port_1119689_0 | SOURCEANDSINK | Fornecimento hidrônico 7
InPort_1091849_1 | SINK | Fornecimento hidrônico 1
OutPort_1086804_6 | SOURCE | Fornecimento hidrônico 1
InPort_1091942_2 | SINK | Fornecimento hidrônico 2
OutPort_1086804_7 | SOURCE | Fornecimento hidrônico 2
Port_1086804_8 | SOURCEANDSINK
Port_1086822_5 | SOURCEANDSINK | Fornecimento hidrônico 19
Port_1120899_0 | SOURCEANDSINK | Fornecimento hidrônico 19
InPort_1098375_0 | SINK | Fornecimento hidrônico 1
OutPort_1086822_6 | SOURCE | Fornecimento hidrônico 1
InPort_1093834_1 | SINK | Fornecimento hidrônico 2
OutPort_1086822_7 | SOURCE | Fornecimento hidrônico 2
Port_1086822_8 | SOURCEANDSINK
Port_1086851_5 | SOURCEANDSINK | Fornecimento hidrônico 16
Port_1120517_0 | SOURCEANDSINK | Fornecimento hidrônico 16
InPort_1092918_1 | SINK | Fornecimento hidrônico 1
OutPort_1086851_6 | SOURCE | Fornecimento hidrônico 1
InPort_1094976_1 | SINK | Fornecimento hidrônico 2
OutPort_1086851_7 | SOURCE | Fornecimento hidrônico 2
Port_1086851_8 | SOURCEANDSINK
Port_1086865_5 | SOURCEANDSINK | Fornecimento hidrônico 8
Port_1119701_0 | SOURCEANDSINK | Fornecimento hidrônico 8
InPort_1091680_1 | SINK | Fornecimento hidrônico 1
OutPort_1086865_6 | SOURCE | Fornecimento hidrônico 1
InPort_1091876_1 | SINK | Fornecimento hidrônico 2
OutPort_1086865_7 | SOURCE | Fornecimento hidrônico 2
Port_1086865_8 | SOURCEANDSINK
Port_1087634_0 | SOURCEANDSINK | Outros 2
Port_1087650_2 | SOURCEANDSINK | Outros 2
Port_1087634_1 | SOURCEANDSINK | Outros 2
Port_1088713_1 | SOURCEANDSINK | Outros 2
Port_1087682_0 | SOURCEANDSINK | Outros 2
Port_1087833_1 | SOURCEANDSINK | Outros 2
Port_1087682_1 | SOURCEANDSINK | Outros 2
Port_1088715_1 | SOURCEANDSINK | Outros 2
Port_1087844_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1087856_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1087844_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1087866_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1087858_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089593_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1087858_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1087985_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1087866_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089594_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1087884_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088000_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1087884_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088005_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1087983_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1087985_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1087983_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088005_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1087996_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088000_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088210_0 | SOURCEANDSINK | Outros 2
Port_1088224_2 | SOURCEANDSINK | Outros 2
Port_1088210_1 | SOURCEANDSINK | Outros 2
Port_1088378_1 | SOURCEANDSINK | Outros 2

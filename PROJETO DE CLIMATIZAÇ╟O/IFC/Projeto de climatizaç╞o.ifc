Properties of the parts of a building model (IFC2X3), part 2 of 5

# IfcDistributionPort (3613)
Name | FlowDirection | Group
Port_1088226_0 | SOURCEANDSINK | Outros 2
Port_1089226_2 | SOURCEANDSINK | Outros 2
Port_1088226_1 | SOURCEANDSINK | Outros 2
Port_1088380_2 | SOURCEANDSINK | Outros 2
Port_1088294_0 | SOURCEANDSINK | Outros 2
Port_1088314_2 | SOURCEANDSINK | Outros 2
Port_1088294_1 | SOURCEANDSINK | Outros 2
Port_1088365_1 | SOURCEANDSINK | Outros 2
Port_1088363_0 | SOURCEANDSINK | Outros 2
Port_1088365_2 | SOURCEANDSINK | Outros 2
Port_1088363_1 | SOURCEANDSINK | Outros 2
Port_1088380_1 | SOURCEANDSINK | Outros 2
Port_1088378_2 | SOURCEANDSINK | Outros 2
Port_1089223_0 | SOURCEANDSINK | Outros 2
Port_1088406_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088422_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088406_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089060_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088424_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089386_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088424_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089060_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088466_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088478_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088466_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088499_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088480_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089057_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088480_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088499_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1088534_0 | SOURCEANDSINK | Outros 2
Port_1089325_2 | SOURCEANDSINK | Outros 2
Port_1088534_1 | SOURCEANDSINK | Outros 2
Port_1100840_2 | SOURCEANDSINK | Outros 2
Port_1088556_0 | SOURCEANDSINK | Outros 2
Port_1089325_1 | SOURCEANDSINK | Outros 2
Port_1088556_1 | SOURCEANDSINK | Outros 2
Port_1089028_1 | SOURCEANDSINK | Outros 2
Port_1088713_2 | SOURCEANDSINK | Outros 2
Port_1089003_0 | SOURCEANDSINK | Outros 2
Port_1088715_2 | SOURCEANDSINK | Outros 2
Port_1088945_1 | SOURCEANDSINK | Outros 2
Port_1088726_0 | SOURCEANDSINK | Outros 2
Port_1100825_2 | SOURCEANDSINK | Outros 2
Port_1088726_1 | SOURCEANDSINK | Outros 2
Port_1089030_2 | SOURCEANDSINK | Outros 2
Port_1088945_0 | SOURCEANDSINK | Outros 2
Port_1089006_2 | SOURCEANDSINK | Outros 2
Port_1089002_1 | SOURCEANDSINK | Outros 2
Port_1089006_1 | SOURCEANDSINK | Outros 2
Port_1089002_2 | SOURCEANDSINK | Outros 2
Port_1089008_1 | SOURCEANDSINK | Outros 2
Port_1089002_3 | SOURCEANDSINK | Outros 2
Port_1100825_1 | SOURCEANDSINK | Outros 2
Port_1089003_1 | SOURCEANDSINK | Outros 2
Port_1089008_2 | SOURCEANDSINK | Outros 2
Port_1089028_2 | SOURCEANDSINK | Outros 2
Port_1097322_0 | SOURCEANDSINK | Outros 2
Port_1089030_1 | SOURCEANDSINK | Outros 2
Port_1097226_1 | SOURCEANDSINK | Outros 2
Port_1089055_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089387_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089055_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089057_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089222_1 | SOURCEANDSINK | Outros 2
Port_1089226_1 | SOURCEANDSINK | Outros 2
Port_1089222_2 | SOURCEANDSINK | Outros 2
Port_1089228_1 | SOURCEANDSINK | Outros 2
Port_1089222_3 | SOURCEANDSINK | Outros 2
Port_1089313_0 | SOURCEANDSINK | Outros 2
Port_1089223_1 | SOURCEANDSINK | Outros 2
Port_1089228_2 | SOURCEANDSINK | Outros 2
Port_1089313_1 | SOURCEANDSINK | Outros 2
Port_1089317_1 | SOURCEANDSINK | Outros 2
Port_1089314_0 | SOURCEANDSINK | Outros 2
Port_1089317_2 | SOURCEANDSINK | Outros 2
Port_1089314_1 | SOURCEANDSINK | Outros 2
Port_1089327_1 | SOURCEANDSINK | Outros 2
Port_1089327_2 | SOURCEANDSINK | Outros 2
Port_1100840_1 | SOURCEANDSINK | Outros 2
Port_1089378_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100845_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089378_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089555_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089386_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089387_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089386_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100845_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089535_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089555_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089535_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102302_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089582_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100831_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089582_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102300_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089591_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089593_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089591_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089597_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089593_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089594_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089597_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100831_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089630_0 | SOURCEANDSINK | Outros 2
Port_1097321_3 | SOURCEANDSINK | Outros 2
Port_1089630_1 | SOURCEANDSINK | Outros 2
Port_1097341_1 | SOURCEANDSINK | Outros 2
Port_1089779_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102325_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089779_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102302_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089895_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102339_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1089895_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102343_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090037_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090190_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090037_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090195_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090095_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090290_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090095_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090300_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090128_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101095_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090128_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101097_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090168_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090178_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090168_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090195_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090170_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100922_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090170_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100909_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090170_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090178_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090171_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100893_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090171_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100895_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090188_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090190_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090279_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101085_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090279_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101087_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090292_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100931_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090292_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100915_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090292_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090300_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090293_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100901_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090293_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100903_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090317_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090331_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090317_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100970_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090333_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090787_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090333_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090458_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090364_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090380_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090364_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090458_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090473_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090485_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090473_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090499_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090499_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090847_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090517_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090533_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090517_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090547_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090535_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090846_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090535_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090547_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090559_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091249_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090559_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091259_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090603_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091517_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090603_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091527_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090675_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091380_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090675_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091385_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090715_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091052_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090715_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091057_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090771_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100947_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090771_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100949_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090783_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090787_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090783_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100972_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090783_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100947_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090793_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100939_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090793_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100941_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090804_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090814_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090804_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090816_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090806_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101095_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090806_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100924_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090806_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090814_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090807_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100922_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090807_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100924_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090816_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100939_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090820_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100941_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090820_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100949_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090837_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100999_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090837_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090944_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090844_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090846_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090844_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090850_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090846_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090847_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090850_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101052_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090860_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101052_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090860_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101018_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090862_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100970_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090862_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100972_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090870_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090944_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090870_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100957_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090928_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090938_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090928_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090946_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090930_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101085_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090930_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100933_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090930_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090938_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090931_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100931_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090931_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100933_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090946_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100957_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1090996_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091360_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1090996_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101135_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091004_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101097_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091004_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101111_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091031_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091041_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091031_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091057_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091033_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101119_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091033_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101113_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091033_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091041_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091034_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101111_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091034_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101113_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091050_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091052_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091216_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101087_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091216_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101103_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091251_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091520_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091251_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101105_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091251_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091259_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091252_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101103_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091252_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101105_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091358_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091368_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091358_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091385_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091360_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101121_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091360_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091368_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091361_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101119_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091361_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101121_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091378_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091380_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091505_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101141_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091505_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092009_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091519_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101141_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091519_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101129_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091519_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091527_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091520_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101129_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091588_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1118720_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091588_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1118722_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091600_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1118720_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091600_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101135_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091670_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091680_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091670_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091690_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091682_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091979_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091682_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091851_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091690_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091976_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091782_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091849_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091782_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091851_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091866_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091876_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091866_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091884_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091878_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092026_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091878_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091933_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091884_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092027_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091918_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091937_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091918_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091942_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091931_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091935_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091931_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091937_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091933_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091935_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091962_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1118738_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091962_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1118740_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091973_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091975_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091973_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091986_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091975_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091979_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091975_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091981_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091976_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091981_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091986_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1118738_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091990_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1118740_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091990_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1118722_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1091999_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092009_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1091999_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092041_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092011_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101157_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092011_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092041_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092024_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092035_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092024_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092037_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092026_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092027_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092026_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092035_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092037_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101157_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092237_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092737_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092237_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092338_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092243_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092737_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092243_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101286_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092311_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101284_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092311_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092338_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092327_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100893_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092327_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093309_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092327_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101284_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092363_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092379_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092363_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092387_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092381_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092639_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092381_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092459_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092387_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092636_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092407_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092457_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092407_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092459_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092488_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092498_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092488_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092506_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092506_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094876_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092524_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092576_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092524_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092578_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092578_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094632_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1092624_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101166_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092624_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101168_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092633_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092635_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092633_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092847_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092635_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092639_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092635_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092641_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092636_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092641_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092739_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093030_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092739_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092740_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092739_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101286_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092740_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095553_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092837_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092973_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092837_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092975_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092847_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101166_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092851_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092973_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092851_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101202_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092851_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101168_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092852_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101204_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092852_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101202_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092906_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092918_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092906_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092958_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092956_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092958_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092956_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1092975_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093016_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093039_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093016_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093049_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093027_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093037_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093027_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093039_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093029_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101204_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093029_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101218_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093029_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093037_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093030_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101218_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093043_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093049_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093043_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098469_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093286_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098337_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093286_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093323_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093294_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100901_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093294_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093295_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093294_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1131073_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093295_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100915_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093307_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1131073_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093307_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098318_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093309_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100909_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1093317_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093323_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093317_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093333_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093325_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093333_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093325_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1131075_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093695_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093698_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093695_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093731_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093698_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1131075_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093702_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1131077_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093702_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1131079_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093715_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093717_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093715_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093727_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093717_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094518_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093717_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093723_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093718_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1095623_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093718_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093723_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093727_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1131077_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093731_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1131079_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093824_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093834_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093824_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094760_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093836_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094752_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093836_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094823_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093844_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094823_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093844_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094833_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093958_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094927_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1093958_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1095003_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094306_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101176_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094306_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094879_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094308_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094760_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094308_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094762_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094518_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094826_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094632_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094875_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094750_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094752_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094750_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094762_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094825_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094845_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094825_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094826_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094825_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094833_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094845_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094880_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094866_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094937_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094866_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094939_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094875_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094876_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094875_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101176_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094879_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094937_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094879_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094880_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094925_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094927_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094925_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094939_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094956_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094976_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094956_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094988_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094978_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094988_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094978_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1095011_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094990_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1095007_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1094990_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1095011_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1095001_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1095003_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1095001_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1095007_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1095094_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095104_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095094_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095855_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095166_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095178_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095166_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095190_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095180_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095857_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095180_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095190_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095201_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095217_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095201_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095874_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095255_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095267_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095255_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095277_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095269_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095876_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095269_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095277_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095288_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095306_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095288_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095316_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095308_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095316_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095308_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095324_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095318_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095324_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095318_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095336_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095326_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096114_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095326_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095410_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095336_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096111_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095354_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095408_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095354_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095410_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095442_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095458_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095442_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095468_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095460_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095468_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095460_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095478_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095472_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095478_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095472_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095488_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095488_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096057_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095506_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095516_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095506_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095532_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095518_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096056_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095518_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095532_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095543_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095553_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095543_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096806_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095573_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099272_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095573_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099274_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095581_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099272_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095581_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095597_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095591_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095826_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095591_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096083_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095597_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095827_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095615_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1095623_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1095615_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1096606_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1095645_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096331_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095645_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095661_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095653_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095661_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095653_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095669_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095663_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101271_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095663_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096046_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095669_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095978_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095681_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095793_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095681_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095915_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095708_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095963_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095708_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095876_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095783_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095793_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095783_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095807_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095804_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095840_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095804_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095807_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095811_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095836_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095811_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095840_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095824_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095826_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095824_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095836_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095826_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101264_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095827_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101264_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095855_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1102665_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095857_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1102648_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095874_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095964_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095912_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095915_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095912_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1102660_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095919_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1102660_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095919_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1102664_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095953_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101243_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095953_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095987_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095963_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095964_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095963_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101243_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095967_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101245_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095967_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095987_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095977_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101271_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095977_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095978_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1095977_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101245_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096038_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096046_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096038_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096066_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096048_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101273_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096048_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096066_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096056_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096057_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096056_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101273_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096075_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096083_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096075_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096094_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096086_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096094_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096086_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096125_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096096_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101269_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096096_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096125_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096108_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096110_3 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096108_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096121_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096110_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096114_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096110_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096117_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096111_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096117_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096121_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101269_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096328_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096331_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096328_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096345_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096335_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1096335_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1096540_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1096345_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096349_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096349_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096537_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1096540_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1096537_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1096602_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1096544_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1096602_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1096544_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1096606_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1096669_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096763_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096669_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098581_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096683_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098467_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096683_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098469_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096760_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096763_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096760_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096802_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096767_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096802_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096767_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096806_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096908_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100877_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096908_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100879_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096916_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100895_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096916_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100877_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096919_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100861_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096919_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100863_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096931_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100861_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096931_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100879_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096933_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101884_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096933_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101924_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096941_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100863_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1096941_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100804_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1097026_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100885_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097026_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100887_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097034_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100903_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097034_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100885_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097036_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100869_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097036_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100871_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097044_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100869_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097044_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100887_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097046_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102058_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097046_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102060_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097056_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100871_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097056_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097184_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097181_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097183_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097181_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102339_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097183_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102058_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097183_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097653_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097184_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097653_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1097226_0 | SOURCEANDSINK | Outros 2
Port_1097321_1 | SOURCEANDSINK | Outros 2
Port_1097321_2 | SOURCEANDSINK | Outros 2
Port_1097322_1 | SOURCEANDSINK | Outros 2
Port_1097338_0 | SOURCEANDSINK | Outros 2
Port_1097341_2 | SOURCEANDSINK | Outros 2
Port_1097338_1 | SOURCEANDSINK | Outros 2
Port_1097510_1 | SOURCEANDSINK | Outros 2
Port_1097476_0 | SOURCEANDSINK | Outros 2
Port_1097506_2 | SOURCEANDSINK | Outros 2
Port_1097476_1 | SOURCEANDSINK | Outros 2
Port_1097510_2 | SOURCEANDSINK | Outros 2
Port_1097492_0 | SOURCEANDSINK | Outros 2
Port_1097496_3 | SOURCEANDSINK | Outros 2
Port_1097492_1 | SOURCEANDSINK | Outros 2
Port_1097500_1 | SOURCEANDSINK | Outros 2
Port_1097493_0 | SOURCEANDSINK | Outros 2
Port_1097500_2 | SOURCEANDSINK | Outros 2
Port_1097493_1 | SOURCEANDSINK | Outros 2
Port_1097506_1 | SOURCEANDSINK | Outros 2
Port_1097496_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1101884_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1097496_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100806_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1097497_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100804_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1097497_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1100806_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098315_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098318_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098315_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098345_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098322_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098341_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098322_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098345_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098335_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098337_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098335_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098341_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1098375_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098467_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098578_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098581_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098578_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098717_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098585_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098717_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098585_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098995_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098992_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098995_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1098992_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099084_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099078_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099084_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099078_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099264_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099262_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099264_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099262_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099274_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099374_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099374_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1099376_1 | SOURCEANDSINK | Outros 1
OutPort_1099376_2 | SOURCE | Outros 1
Port_1099804_22 | SOURCEANDSINK
Port_1099804_23 | SOURCEANDSINK
Port_1099804_24 | SOURCEANDSINK
Port_1099804_25 | SOURCEANDSINK
Port_1099804_26 | SOURCEANDSINK
Port_1099804_27 | SOURCEANDSINK
Port_1099804_28 | SOURCEANDSINK
Port_1099804_29 | SOURCEANDSINK
Port_1099804_30 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100608_1 | SOURCEANDSINK | Fornecimento hidrônico 2
InPort_1100212_0 | SINK | Outros 3
OutPort_1099804_31 | SOURCE | Outros 3
Port_1099804_32 | SOURCEANDSINK
Port_1099804_33 | SOURCEANDSINK
Port_1099804_34 | SOURCEANDSINK
Port_1099804_35 | SOURCEANDSINK
Port_1099804_36 | SOURCEANDSINK
Port_1099804_37 | SOURCEANDSINK
Port_1100212_1 | SOURCEANDSINK | Outros 3
Port_1100240_2 | SOURCEANDSINK | Outros 3
Port_1100224_0 | SOURCEANDSINK | Outros 3
Port_1100240_1 | SOURCEANDSINK | Outros 3
Port_1100224_1 | SOURCEANDSINK | Outros 3
Port_1100248_2 | SOURCEANDSINK | Outros 3
Port_1100242_0 | SOURCEANDSINK | Outros 3
Port_1100248_1 | SOURCEANDSINK | Outros 3
Port_1100242_1 | SOURCEANDSINK | Outros 3
Port_1100562_2 | SOURCEANDSINK | Outros 3
Port_1100434_0 | SOURCEANDSINK | Outros 3
Port_1100562_1 | SOURCEANDSINK | Outros 3
Port_1100434_1 | SOURCEANDSINK | Outros 3
Port_1100564_1 | SOURCEANDSINK | Outros 3
Port_1100473_0 | SOURCEANDSINK | Outros 3
Port_1101919_1 | SOURCEANDSINK | Outros 3
Port_1100473_1 | SOURCEANDSINK | Outros 3
Port_1100564_2 | SOURCEANDSINK | Outros 3
Port_1100593_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100608_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100593_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100618_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100610_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100618_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100610_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100626_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100620_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100626_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100620_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100636_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100628_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100636_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100628_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100669_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100651_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100669_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100651_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101966_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100993_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100999_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1100993_1 | SOURCEANDSINK | Fornecimento hidrônico 2

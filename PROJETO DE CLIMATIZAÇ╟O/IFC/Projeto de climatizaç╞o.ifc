Properties of the parts of a building model (IFC2X3), part 4 of 5

# IfcDistributionPort (3613)
Name | FlowDirection | Group
Port_1120517_1 | SOURCEANDSINK | Fornecimento hidrônico 16
Port_1120520_3 | SOURCEANDSINK | Fornecimento hidrônico 16
Port_1120520_1 | SOURCEANDSINK | Outros 10
Port_1120850_0 | SOURCEANDSINK | Outros 10
Port_1120520_2 | SOURCEANDSINK | Outros 10
Port_1120521_0 | SOURCEANDSINK | Outros 10
Port_1120521_1 | SOURCEANDSINK | Outros 10
Port_1120822_1 | SOURCEANDSINK | Outros 10
Port_1120527_0 | SOURCEANDSINK | Outros 10
Port_1120648_2 | SOURCEANDSINK | Outros 10
Port_1120527_1 | SOURCEANDSINK | Outros 10
Port_1120633_1 | SOURCEANDSINK | Outros 10
Port_1120645_1 | SOURCEANDSINK | Fornecimento hidrônico 18
Port_1120648_3 | SOURCEANDSINK | Fornecimento hidrônico 18
Port_1120648_1 | SOURCEANDSINK | Outros 10
Port_1120649_0 | SOURCEANDSINK | Outros 10
Port_1120649_1 | SOURCEANDSINK | Outros 10
Port_1120822_2 | SOURCEANDSINK | Outros 10
Port_1120841_0 | SOURCEANDSINK | Outros 10
Port_1120841_1 | SOURCEANDSINK | Outros 10
Port_1120899_1 | SOURCEANDSINK | Outros 10
Port_1120849_2 | SOURCEANDSINK | Outros 10
Port_1120850_1 | SOURCEANDSINK | Outros 10
Port_1120849_3 | SOURCEANDSINK | Outros 10
Port_1120903_0 | SOURCEANDSINK | Outros 10
Port_1120976_1 | SOURCEANDSINK | Outros 10
Port_1120903_1 | SOURCEANDSINK | Outros 10
Port_1120963_1 | SOURCEANDSINK | Outros 10
Port_1120912_0 | SOURCEANDSINK | Outros 10
Port_1120914_3 | SOURCEANDSINK | Outros 10
Port_1120912_1 | SOURCEANDSINK | Outros 10
Port_1121089_1 | SOURCEANDSINK | Outros 10
Port_1120914_2 | SOURCEANDSINK | Outros 10
Port_1120915_1 | SOURCEANDSINK | Outros 10
Port_1120967_0 | SOURCEANDSINK | Outros 10
Port_1121015_2 | SOURCEANDSINK | Outros 10
Port_1120967_1 | SOURCEANDSINK | Outros 10
Port_1121035_1 | SOURCEANDSINK | Outros 10
Port_1120974_0 | SOURCEANDSINK | Outros 10
Port_1120976_3 | SOURCEANDSINK | Outros 10
Port_1120974_1 | SOURCEANDSINK | Outros 10
Port_1121015_1 | SOURCEANDSINK | Outros 10
Port_1120976_2 | SOURCEANDSINK | Outros 10
Port_1120977_0 | SOURCEANDSINK | Outros 10
Port_1121089_2 | SOURCEANDSINK | Outros 10
Port_1120977_1 | SOURCEANDSINK | Outros 10
Port_1122235_0 | SOURCEANDSINK | Outros 11
Port_1122702_1 | SOURCEANDSINK | Outros 11
Port_1122235_1 | SOURCEANDSINK | Outros 11
Port_1122560_1 | SOURCEANDSINK | Outros 11
Port_1122428_0 | SOURCEANDSINK | Outros 11
Port_1122600_1 | SOURCEANDSINK | Outros 11
Port_1122428_1 | SOURCEANDSINK | Outros 11
Port_1122440_0 | SOURCEANDSINK | Outros 11
Port_1122501_1 | SOURCEANDSINK | Outros 11
Port_1122440_1 | SOURCEANDSINK | Outros 11
Port_1122625_2 | SOURCEANDSINK | Outros 11
Port_1122448_0 | SOURCEANDSINK | Outros 11
Port_1122448_1 | SOURCEANDSINK | Outros 11
Port_1122494_0 | SOURCEANDSINK | Outros 11
Port_1122501_2 | SOURCEANDSINK | Outros 11
Port_1122494_1 | SOURCEANDSINK | Outros 11
Port_1122503_1 | SOURCEANDSINK | Outros 11
Port_1122495_0 | SOURCEANDSINK | Outros 11
Port_1122503_2 | SOURCEANDSINK | Outros 11
Port_1122495_1 | SOURCEANDSINK | Outros 11
Port_1122507_1 | SOURCEANDSINK | Outros 11
OutPort_1122507_2 | SOURCE | Outros 11
Port_1122560_2 | SOURCEANDSINK | Outros 11
Port_1122601_0 | SOURCEANDSINK | Outros 11
Port_1122579_1 | SOURCEANDSINK | Fornecimento hidrônico 22
Port_1122582_3 | SOURCEANDSINK | Fornecimento hidrônico 22
Port_1122582_1 | SOURCEANDSINK | Outros 11
Port_1122582_2 | SOURCEANDSINK | Outros 11
Port_1122583_0 | SOURCEANDSINK | Outros 11
Port_1122625_1 | SOURCEANDSINK | Outros 11
Port_1122583_1 | SOURCEANDSINK | Outros 11
Port_1122597_1 | SOURCEANDSINK | Fornecimento hidrônico 23
Port_1122600_3 | SOURCEANDSINK | Fornecimento hidrônico 23
Port_1122600_2 | SOURCEANDSINK | Outros 11
Port_1122601_1 | SOURCEANDSINK | Outros 11
Port_1122699_1 | SOURCEANDSINK | Fornecimento hidrônico 24
Port_1122702_3 | SOURCEANDSINK | Fornecimento hidrônico 24
Port_1122702_2 | SOURCEANDSINK | Outros 11
Port_1122703_1 | SOURCEANDSINK | Outros 11
Port_1122703_0 | SOURCEANDSINK | Outros 11
Port_1122720_1 | SOURCEANDSINK | Outros 11
Port_1122717_1 | SOURCEANDSINK | Fornecimento hidrônico 25
Port_1122720_3 | SOURCEANDSINK | Fornecimento hidrônico 25
Port_1122720_2 | SOURCEANDSINK | Outros 11
Port_1122721_1 | SOURCEANDSINK | Outros 11
Port_1122721_0 | SOURCEANDSINK | Outros 11
Port_1122766_1 | SOURCEANDSINK | Outros 11
Port_1122735_1 | SOURCEANDSINK | Fornecimento hidrônico 26
Port_1122751_0 | SOURCEANDSINK | Fornecimento hidrônico 26
Port_1122747_1 | SOURCEANDSINK | Fornecimento hidrônico 27
Port_1122750_3 | SOURCEANDSINK | Fornecimento hidrônico 27
Port_1122750_1 | SOURCEANDSINK | Outros 11
Port_1122767_0 | SOURCEANDSINK | Outros 11
Port_1122750_2 | SOURCEANDSINK | Outros 11
Port_1122751_1 | SOURCEANDSINK | Outros 11
Port_1122763_1 | SOURCEANDSINK | Fornecimento hidrônico 28
Port_1122766_3 | SOURCEANDSINK | Fornecimento hidrônico 28
Port_1122766_2 | SOURCEANDSINK | Outros 11
Port_1122767_1 | SOURCEANDSINK | Outros 11
Port_1122773_0 | SOURCEANDSINK | Outros 12
Port_1123387_1 | SOURCEANDSINK | Outros 12
Port_1122773_1 | SOURCEANDSINK | Outros 12
Port_1123086_1 | SOURCEANDSINK | Outros 12
Port_1123078_0 | SOURCEANDSINK | Outros 12
Port_1123086_2 | SOURCEANDSINK | Outros 12
Port_1123078_1 | SOURCEANDSINK | Outros 12
Port_1123105_1 | SOURCEANDSINK | Outros 12
Port_1123102_0 | SOURCEANDSINK | Outros 12
Port_1123117_1 | SOURCEANDSINK | Outros 12
Port_1123102_1 | SOURCEANDSINK | Outros 12
Port_1123105_2 | SOURCEANDSINK | Outros 12
Port_1123109_0 | SOURCEANDSINK | Outros 12
Port_1123117_2 | SOURCEANDSINK | Outros 12
Port_1123109_1 | SOURCEANDSINK | Outros 12
Port_1123137_0 | SOURCEANDSINK | Outros 12
Port_1123309_2 | SOURCEANDSINK | Outros 12
Port_1123137_1 | SOURCEANDSINK | Outros 12
Port_1123149_0 | SOURCEANDSINK | Outros 12
Port_1123245_2 | SOURCEANDSINK | Outros 12
Port_1123149_1 | SOURCEANDSINK | Outros 12
Port_1123230_1 | SOURCEANDSINK | Outros 12
Port_1123155_1 | SOURCEANDSINK | Outros 12
Port_1123155_2 | SOURCEANDSINK | Outros 12
Port_1123242_1 | SOURCEANDSINK | Fornecimento hidrônico 30
Port_1123245_3 | SOURCEANDSINK | Fornecimento hidrônico 30
Port_1123245_1 | SOURCEANDSINK | Outros 12
Port_1123246_1 | SOURCEANDSINK | Outros 12
Port_1123246_0 | SOURCEANDSINK | Outros 12
Port_1123289_2 | SOURCEANDSINK | Outros 12
Port_1123266_1 | SOURCEANDSINK | Fornecimento hidrônico 31
Port_1123269_3 | SOURCEANDSINK | Fornecimento hidrônico 31
Port_1123269_1 | SOURCEANDSINK | Outros 12
Port_1123270_1 | SOURCEANDSINK | Outros 12
Port_1123269_2 | SOURCEANDSINK | Outros 12
Port_1123290_0 | SOURCEANDSINK | Outros 12
Port_1123270_0 | SOURCEANDSINK | Outros 12
Port_1123286_1 | SOURCEANDSINK | Fornecimento hidrônico 32
Port_1123289_3 | SOURCEANDSINK | Fornecimento hidrônico 32
Port_1123289_1 | SOURCEANDSINK | Outros 12
Port_1123290_1 | SOURCEANDSINK | Outros 12
Port_1123306_1 | SOURCEANDSINK | Fornecimento hidrônico 33
Port_1123309_3 | SOURCEANDSINK | Fornecimento hidrônico 33
Port_1123309_1 | SOURCEANDSINK | Outros 12
Port_1123310_1 | SOURCEANDSINK | Outros 12
Port_1123310_0 | SOURCEANDSINK | Outros 12
Port_1123327_2 | SOURCEANDSINK | Outros 12
Port_1123324_1 | SOURCEANDSINK | Fornecimento hidrônico 34
Port_1123327_3 | SOURCEANDSINK | Fornecimento hidrônico 34
Port_1123327_1 | SOURCEANDSINK | Outros 12
Port_1123328_1 | SOURCEANDSINK | Outros 12
Port_1123328_0 | SOURCEANDSINK | Outros 12
Port_1123349_2 | SOURCEANDSINK | Outros 12
Port_1123343_1 | SOURCEANDSINK
Port_1123346_1 | SOURCEANDSINK | Fornecimento hidrônico 35
Port_1123349_3 | SOURCEANDSINK | Fornecimento hidrônico 35
Port_1123349_1 | SOURCEANDSINK | Outros 12
Port_1123928_0 | SOURCEANDSINK | Outros 12
Port_1123366_1 | SOURCEANDSINK | Fornecimento hidrônico 36
Port_1123369_3 | SOURCEANDSINK | Fornecimento hidrônico 36
Port_1123369_1 | SOURCEANDSINK | Outros 12
Port_1123513_0 | SOURCEANDSINK | Outros 12
Port_1123369_2 | SOURCEANDSINK | Outros 12
Port_1123370_0 | SOURCEANDSINK | Outros 12
Port_1123370_1 | SOURCEANDSINK | Outros 12
Port_1123927_3 | SOURCEANDSINK | Outros 12
Port_1123384_1 | SOURCEANDSINK | Fornecimento hidrônico 37
Port_1123387_3 | SOURCEANDSINK | Fornecimento hidrônico 37
Port_1123387_2 | SOURCEANDSINK | Outros 12
Port_1123388_1 | SOURCEANDSINK | Outros 12
Port_1123388_0 | SOURCEANDSINK | Outros 12
Port_1123405_1 | SOURCEANDSINK | Outros 12
Port_1123402_1 | SOURCEANDSINK | Fornecimento hidrônico 38
Port_1123405_3 | SOURCEANDSINK | Fornecimento hidrônico 38
Port_1123405_2 | SOURCEANDSINK | Outros 12
Port_1123406_0 | SOURCEANDSINK | Outros 12
Port_1123423_1 | SOURCEANDSINK | Outros 12
Port_1123406_1 | SOURCEANDSINK | Outros 12
Port_1123420_1 | SOURCEANDSINK | Fornecimento hidrônico 39
Port_1123423_3 | SOURCEANDSINK | Fornecimento hidrônico 39
Port_1123423_2 | SOURCEANDSINK | Outros 12
Port_1123424_1 | SOURCEANDSINK | Outros 12
Port_1123424_0 | SOURCEANDSINK | Outros 12
Port_1123494_1 | SOURCEANDSINK | Outros 12
Port_1123491_1 | SOURCEANDSINK | Fornecimento hidrônico 40
Port_1123494_3 | SOURCEANDSINK | Fornecimento hidrônico 40
Port_1123494_2 | SOURCEANDSINK | Outros 12
Port_1123495_1 | SOURCEANDSINK | Outros 12
Port_1123495_0 | SOURCEANDSINK | Outros 12
Port_1124110_1 | SOURCEANDSINK | Outros 12
Port_1123509_1 | SOURCEANDSINK | Fornecimento hidrônico 41
Port_1123512_3 | SOURCEANDSINK | Fornecimento hidrônico 41
Port_1123512_1 | SOURCEANDSINK | Outros 12
Port_1124111_0 | SOURCEANDSINK | Outros 12
Port_1123512_2 | SOURCEANDSINK | Outros 12
Port_1123513_1 | SOURCEANDSINK | Outros 12
Port_1123529_0 | SOURCEANDSINK | Outros 13
Port_1123753_1 | SOURCEANDSINK | Outros 13
Port_1123529_1 | SOURCEANDSINK | Outros 13
Port_1123638_1 | SOURCEANDSINK | Outros 13
Port_1123582_0 | SOURCEANDSINK | Outros 13
Port_1123735_1 | SOURCEANDSINK | Outros 13
Port_1123582_1 | SOURCEANDSINK | Outros 13
Port_1123698_1 | SOURCEANDSINK | Outros 13
Port_1123638_2 | SOURCEANDSINK | Outros 13
Port_1123736_0 | SOURCEANDSINK | Outros 13
Port_1123695_0 | SOURCEANDSINK | Outros 13
Port_1123698_2 | SOURCEANDSINK | Outros 13
Port_1123695_1 | SOURCEANDSINK | Outros 13
Port_1123710_1 | SOURCEANDSINK | Outros 13
Port_1123702_0 | SOURCEANDSINK | Outros 13
Port_1123710_2 | SOURCEANDSINK | Outros 13
Port_1123702_1 | SOURCEANDSINK | Outros 13
Port_1123729_1 | SOURCEANDSINK
Port_1123732_1 | SOURCEANDSINK | Fornecimento hidrônico 42
Port_1123735_3 | SOURCEANDSINK | Fornecimento hidrônico 42
Port_1123735_2 | SOURCEANDSINK | Outros 13
Port_1123736_1 | SOURCEANDSINK | Outros 13
Port_1123750_1 | SOURCEANDSINK | Fornecimento hidrônico 43
Port_1123753_3 | SOURCEANDSINK | Fornecimento hidrônico 43
Port_1123753_2 | SOURCEANDSINK | Outros 13
Port_1123754_1 | SOURCEANDSINK | Outros 13
Port_1123754_0 | SOURCEANDSINK | Outros 13
Port_1123873_1 | SOURCEANDSINK | Outros 13
Port_1123919_0 | SOURCEANDSINK | Outros 12
Port_1124090_2 | SOURCEANDSINK | Outros 12
Port_1123919_1 | SOURCEANDSINK | Outros 12
Port_1124075_1 | SOURCEANDSINK | Outros 12
Port_1123927_1 | SOURCEANDSINK | Outros 12
Port_1123927_2 | SOURCEANDSINK | Outros 12
Port_1123928_1 | SOURCEANDSINK | Outros 12
Port_1124087_1 | SOURCEANDSINK | Fornecimento hidrônico 46
Port_1124090_3 | SOURCEANDSINK | Fornecimento hidrônico 46
Port_1124090_1 | SOURCEANDSINK | Outros 12
Port_1124091_1 | SOURCEANDSINK | Outros 12
Port_1124091_0 | SOURCEANDSINK | Outros 12
Port_1124107_1 | SOURCEANDSINK | Fornecimento hidrônico 47
Port_1124110_3 | SOURCEANDSINK | Fornecimento hidrônico 47
Port_1124110_2 | SOURCEANDSINK | Outros 12
Port_1124111_1 | SOURCEANDSINK | Outros 12

# IfcFlowFitting: Bucha de redução reta - Soldada - CU:Padrão (306)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Padrão; sets with these values: 2
Name (Bucha de redução reta - Soldada - CU:Padrão:...) | In | Group
1087650 | Nível 1 | Outros 2
1087833 | Nível 1 | Outros 2
1087856 | Nível 1 | Fornecimento hidrônico 2
1088000 | Nível 1 | Fornecimento hidrônico 2
1088224 | Nível 1 | Outros 2
1088314 | Nível 1 | Outros 2
1088422 | Nível 1 | Fornecimento hidrônico 2
1088478 | Nível 1 | Fornecimento hidrônico 2
1089006 | Nível 1 | Outros 2
1089008 | Nível 1 | Outros 2
1089057 | Nível 1 | Fornecimento hidrônico 2
1089226 | Nível 1 | Outros 2
1089228 | Nível 1 | Outros 2
1090178 | Nível 1 | Fornecimento hidrônico 1
1090190 | Nível 1 | Fornecimento hidrônico 1
1090290 | Nível 1 | Fornecimento hidrônico 2
1090300 | Nível 1 | Fornecimento hidrônico 2
1090331 | Nível 1 | Fornecimento hidrônico 1
1090380 | Nível 1 | Fornecimento hidrônico 1
1090485 | Nível 1 | Fornecimento hidrônico 2
1090533 | Nível 1 | Fornecimento hidrônico 2
1090787 | Nível 1 | Fornecimento hidrônico 1
1090814 | Nível 1 | Fornecimento hidrônico 1
1090938 | Nível 1 | Fornecimento hidrônico 2
1091041 | Nível 1 | Fornecimento hidrônico 1
1091052 | Nível 1 | Fornecimento hidrônico 1
1091249 | Nível 1 | Fornecimento hidrônico 2
1091259 | Nível 1 | Fornecimento hidrônico 2
1091368 | Nível 1 | Fornecimento hidrônico 1
1091380 | Nível 1 | Fornecimento hidrônico 1
1091517 | Nível 1 | Fornecimento hidrônico 2
1091527 | Nível 1 | Fornecimento hidrônico 2
1091680 | Nível 1 | Fornecimento hidrônico 1
1091849 | Nível 1 | Fornecimento hidrônico 1
1091876 | Nível 1 | Fornecimento hidrônico 2
1091935 | Nível 1 | Fornecimento hidrônico 2
1091942 | Nível 1 | Fornecimento hidrônico 2
1091979 | Nível 1 | Fornecimento hidrônico 1
1091981 | Nível 1 | Fornecimento hidrônico 1
1092035 | Nível 1 | Fornecimento hidrônico 2
1092379 | Nível 1 | Fornecimento hidrônico 1
1092457 | Nível 1 | Fornecimento hidrônico 1
1092498 | Nível 1 | Fornecimento hidrônico 2
1092576 | Nível 1 | Fornecimento hidrônico 2
1092639 | Nível 1 | Fornecimento hidrônico 1
1092641 | Nível 1 | Fornecimento hidrônico 1
1092918 | Nível 1 | Fornecimento hidrônico 1
1092973 | Nível 1 | Fornecimento hidrônico 1
1093037 | Nível 1 | Fornecimento hidrônico 1
1093723 | Nível 1 | Fornecimento hidrônico 2
1093834 | Nível 1 | Fornecimento hidrônico 2
1094518 | Nível 1 | Fornecimento hidrônico 2
1094833 | Nível 1 | Fornecimento hidrônico 2
1094845 | Nível 1 | Fornecimento hidrônico 2
1094937 | Nível 1 | Fornecimento hidrônico 2
1094976 | Nível 1 | Fornecimento hidrônico 2
1095104 | Nível 1 | Fornecimento hidrônico 1
1095178 | Nível 1 | Fornecimento hidrônico 1
1095217 | Nível 1 | Fornecimento hidrônico 1
1095267 | Nível 1 | Fornecimento hidrônico 1
1095306 | Nível 1 | Fornecimento hidrônico 1
1095408 | Nível 1 | Fornecimento hidrônico 1
1095458 | Nível 1 | Fornecimento hidrônico 1
1095516 | Nível 1 | Fornecimento hidrônico 1
1096114 | Nível 1 | Fornecimento hidrônico 1
1096117 | Nível 1 | Fornecimento hidrônico 1
1097653 | Nível 1 | Fornecimento hidrônico 2
1098467 | Nível 1 | Fornecimento hidrônico 1
1099374 | Nível 2 | Fornecimento hidrônico 1
1099376 | Nível 2 | Outros 1
1100608 | Nível 2 | Fornecimento hidrônico 2
1100804 | Nível 1 | Fornecimento hidrônico 1
1100806 | Nível 1 | Fornecimento hidrônico 1
1100825 | Nível 1 | Outros 2
1100831 | Nível 1 | Fornecimento hidrônico 2
1100840 | Nível 1 | Outros 2
1100845 | Nível 1 | Fornecimento hidrônico 2
1100861 | Nível 1 | Fornecimento hidrônico 1
1100863 | Nível 1 | Fornecimento hidrônico 1
1100869 | Nível 1 | Fornecimento hidrônico 2
1100871 | Nível 1 | Fornecimento hidrônico 2
1100877 | Nível 1 | Fornecimento hidrônico 1
1100879 | Nível 1 | Fornecimento hidrônico 1
1100885 | Nível 1 | Fornecimento hidrônico 2
1100887 | Nível 1 | Fornecimento hidrônico 2
1100893 | Nível 1 | Fornecimento hidrônico 1
1100895 | Nível 1 | Fornecimento hidrônico 1
1100901 | Nível 1 | Fornecimento hidrônico 2
1100903 | Nível 1 | Fornecimento hidrônico 2
1100909 | Nível 1 | Fornecimento hidrônico 1
1100915 | Nível 1 | Fornecimento hidrônico 2
1100922 | Nível 1 | Fornecimento hidrônico 1
1100924 | Nível 1 | Fornecimento hidrônico 1
1100931 | Nível 1 | Fornecimento hidrônico 2
1100933 | Nível 1 | Fornecimento hidrônico 2
1100939 | Nível 1 | Fornecimento hidrônico 1
1100941 | Nível 1 | Fornecimento hidrônico 1
1100947 | Nível 1 | Fornecimento hidrônico 1
1100949 | Nível 1 | Fornecimento hidrônico 1
1100957 | Nível 1 | Fornecimento hidrônico 2
1100972 | Nível 1 | Fornecimento hidrônico 1
1101052 | Nível 1 | Fornecimento hidrônico 2
1101085 | Nível 1 | Fornecimento hidrônico 2
1101087 | Nível 1 | Fornecimento hidrônico 2
1101095 | Nível 1 | Fornecimento hidrônico 1
1101097 | Nível 1 | Fornecimento hidrônico 1
1101103 | Nível 1 | Fornecimento hidrônico 2
1101105 | Nível 1 | Fornecimento hidrônico 2
1101111 | Nível 1 | Fornecimento hidrônico 1
1101113 | Nível 1 | Fornecimento hidrônico 1
1101119 | Nível 1 | Fornecimento hidrônico 1
1101121 | Nível 1 | Fornecimento hidrônico 1
1101129 | Nível 1 | Fornecimento hidrônico 2
1101135 | Nível 1 | Fornecimento hidrônico 1
1101141 | Nível 1 | Fornecimento hidrônico 2
1101157 | Nível 1 | Fornecimento hidrônico 2
1101166 | Nível 1 | Fornecimento hidrônico 1
1101168 | Nível 1 | Fornecimento hidrônico 1
1101176 | Nível 1 | Fornecimento hidrônico 2
1101202 | Nível 1 | Fornecimento hidrônico 1
1101204 | Nível 1 | Fornecimento hidrônico 1
1101218 | Nível 1 | Fornecimento hidrônico 1
1101243 | Nível 1 | Fornecimento hidrônico 1
1101245 | Nível 1 | Fornecimento hidrônico 1
1101264 | Nível 1 | Fornecimento hidrônico 1
1101269 | Nível 1 | Fornecimento hidrônico 1
1101271 | Nível 1 | Fornecimento hidrônico 1
1101273 | Nível 1 | Fornecimento hidrônico 1
1101284 | Nível 1 | Fornecimento hidrônico 1
1101286 | Nível 1 | Fornecimento hidrônico 1
1101884 | Nível 1 | Fornecimento hidrônico 1
1102058 | Nível 1 | Fornecimento hidrônico 2
1102333 | Nível 1 | Fornecimento hidrônico 2
1102668 | Nível 1 | Fornecimento hidrônico 1
1102670 | Nível 1 | Fornecimento hidrônico 1
1103985 | Nível 2 | Outros 5
1104085 | Nível 2 | Outros 5
1104116 | Nível 2 | Outros 6
1104211 | Nível 2 | Outros 6
1104522 | Nível 2 | Outros 5
1104524 | Nível 2 | Outros 5
1104570 | Nível 2 | Outros 4
1104836 | Nível 2 | Outros 4
1104840 | Nível 2 | Outros 4
1104865 | Nível 2 | Outros 6
1104964 | Nível 2 | Outros 6
1105115 | Nível 2 | Outros 4
1105117 | Nível 2 | Outros 4
1105144 | Nível 2 | Outros 6
1105199 | Nível 2 | Outros 4
1105201 | Nível 2 | Outros 4
1105243 | Nível 2 | Outros 6
1105246 | Nível 2 | Outros 6
1105338 | Nível 2 | Outros 4
1105340 | Nível 2 | Outros 4
1105374 | Nível 2 | Outros 6
1105376 | Nível 2 | Outros 6
1105492 | Nível 2 | Outros 4; Retorno hidrônico 2
1105693 | Nível 2 | Outros 4
1105735 | Nível 2 | Outros 4
1105792 | Nível 2 | Outros 6
1105874 | Nível 2 | Outros 6
1106046 | Nível 2 | Outros 4
1106048 | Nível 2 | Outros 4
1106311 | Nível 2 | Outros 4
1106431 | Nível 2 | Outros 4
1106488 | Nível 2 | Outros 6
1106490 | Nível 2 | Outros 6
1106688 | Nível 2 | Outros 8
1106827 | Nível 2 | Outros 8
1106894 | Nível 2 | Outros 6
1107074 | Nível 2 | Outros 6
1107078 | Nível 2 | Outros 6
1107260 | Nível 2
1107470 | Nível 2 | Outros 4
1107572 | Nível 2 | Outros 4
1107601 | Nível 2 | Outros 6
1107647 | Nível 2 | Outros 6
1107708 | Nível 2 | Outros 4
1107848 | Nível 2 | Outros 4
1107875 | Nível 2 | Outros 6
1107992 | Nível 2 | Outros 6
1108132 | Nível 2 | Outros 4
1108134 | Nível 2 | Outros 4
1108293 | Nível 2 | Outros 4
1108295 | Nível 2 | Outros 4
1108442 | Nível 2 | Outros 4
1108598 | Nível 2 | Outros 4
1108666 | Nível 2 | Outros 6
1108682 | Nível 2 | Outros 6
1110166 | Nível 2 | Outros 4
1110210 | Nível 2 | Outros 4
1110277 | Nível 2 | Outros 6
1110317 | Nível 2 | Outros 6
1110418 | Nível 2 | Outros 4
1110420 | Nível 2 | Outros 4
1110988 | Nível 2 | Outros 4
1111003 | Nível 2 | Outros 4
1111053 | Nível 2 | Outros 6
1111209 | Nível 2 | Outros 4
1111405 | Nível 2 | Outros 6
1111914 | Nível 2 | Outros 4
1111916 | Nível 2 | Outros 4
1111957 | Nível 2 | Retorno hidrônico 1
1111959 | Nível 2 | Outros 6
1112921 | Nível 2 | Outros 4
1112968 | Nível 2 | Outros 4
1112989 | Nível 2 | Outros 6
1113029 | Nível 2 | Outros 6
1113059 | Nível 2 | Outros 6
1113099 | Nível 2 | Outros 4
1113101 | Nível 2 | Outros 4
1113417 | Nível 2 | Outros 4
1113505 | Nível 2 | Outros 4
1113588 | Nível 2 | Outros 6
1113606 | Nível 2 | Outros 6
1113610 | Nível 2 | Outros 6
1113669 | Nível 2 | Outros 4
1113671 | Nível 2 | Outros 4
1113876 | Nível 2 | Outros 6
1113993 | Nível 2 | Outros 6
1114089 | Nível 2 | Outros 6
1114168 | Nível 2 | Retorno hidrônico 2
1114170 | Nível 2 | Retorno hidrônico 2
1114172 | Nível 2 | Outros 6
1114174 | Nível 2 | Outros 6
1114200 | Nível 2 | Outros 4
1114202 | Nível 2 | Outros 4
1114208 | Nível 2 | Outros 6
1114210 | Nível 2 | Outros 6
1114216 | Nível 2 | Outros 4
1114218 | Nível 2 | Outros 4
1114225 | Nível 2 | Outros 6
1114227 | Nível 2 | Outros 6
1114236 | Nível 2 | Outros 4
1114246 | Nível 2 | Outros 4
1114253 | Nível 2 | Outros 6
1114255 | Nível 2 | Outros 6
1114275 | Nível 2 | Outros 4
1114284 | Nível 2 | Outros 6; Retorno hidrônico 1
1114287 | Nível 2 | Outros 4
1114290 | Nível 2 | Outros 6
1114296 | Nível 2 | Outros 4
1114298 | Nível 2 | Outros 4
1114304 | Nível 2 | Outros 6
1114306 | Nível 2 | Outros 6
1114316 | Nível 2 | Outros 4
1114318 | Nível 2 | Outros 4
1114325 | Nível 2 | Outros 6
1114327 | Nível 2 | Outros 6
1114333 | Nível 2 | Outros 4
1114335 | Nível 2 | Outros 4
1114341 | Nível 2 | Outros 6
1114343 | Nível 2 | Outros 6
1114371 | Nível 2 | Outros 6
1114373 | Nível 2 | Outros 6
1114455 | Nível 2 | Outros 4
1114457 | Nível 2 | Outros 4
1114472 | Nível 2 | Outros 4
1114474 | Nível 2 | Outros 4
1114481 | Nível 2 | Outros 6
1114483 | Nível 2 | Outros 6
1114489 | Nível 2 | Outros 6
1114491 | Nível 2 | Outros 6
1114498 | Nível 2 | Outros 4
1114500 | Nível 2 | Outros 4
1114509 | Nível 2 | Outros 4
1114517 | Nível 2 | Outros 4
1114523 | Nível 2 | Outros 6
1114529 | Nível 2 | Outros 4
1114534 | Nível 2 | Outros 4
1114544 | Nível 2 | Outros 6
1114548 | Nível 2 | Outros 6
1114554 | Nível 2 | Outros 4
1114556 | Nível 2 | Outros 4
1114566 | Nível 2 | Outros 6
1114572 | Nível 2 | Outros 4
1114578 | Nível 2 | Outros 4
1114580 | Nível 2 | Outros 4
1114586 | Nível 2 | Outros 6
1114588 | Nível 2 | Outros 6
1114627 | Nível 2 | Outros 4
1114629 | Nível 2 | Outros 6
1114631 | Nível 2 | Outros 6
1114677 | Nível 2 | Outros 4
1114679 | Nível 2 | Outros 4
1114687 | Nível 2 | Outros 6
1114689 | Nível 2 | Outros 6
1114728 | Nível 2 | Outros 4
1114760 | Nível 2 | Outros 4
1114762 | Nível 2 | Outros 4
1114792 | Nível 2 | Outros 6
1114831 | Nível 2 | Outros 6
1115012 | Nível 2 | Outros 6
1115073 | Nível 2 | Outros 4
1115121 | Nível 2 | Outros 6
1115177 | Nível 2 | Outros 4
1115195 | Nível 2 | Outros 4
1118720 | Nível 1 | Fornecimento hidrônico 1
1118722 | Nível 1 | Fornecimento hidrônico 1
1118738 | Nível 1 | Fornecimento hidrônico 1
1118740 | Nível 1 | Fornecimento hidrônico 1
1131073 | Nível 1 | Fornecimento hidrônico 2
1131075 | Nível 1 | Fornecimento hidrônico 2
1131077 | Nível 1 | Fornecimento hidrônico 2
1131079 | Nível 1 | Fornecimento hidrônico 2

# IfcFlowFitting: Cotovelo - PVC - CW:Padrão (27)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Padrão; sets with these values: 2
Name (Cotovelo - PVC - CW:Padrão:...) | In | Group
1119369 | Nível 1 | Outros 7
1119406 | Nível 1 | Outros 7
1119551 | Nível 1 | Outros 7
1119780 | Nível 1 | Outros 9
1119973 | Nível 1 | Outros 9
1119977 | Nível 1 | Outros 9
1120026 | Nível 1 | Outros 9
1120089 | Nível 1 | Outros 9
1120201 | Nível 1 | Outros 9
1120421 | Nível 1 | Outros 10
1120458 | Nível 1 | Outros 10
1120462 | Nível 1 | Outros 10
1120822 | Nível 1 | Outros 10
1121015 | Nível 1 | Outros 10
1121089 | Nível 1 | Outros 10
1122501 | Nível 2 | Outros 11
1122503 | Nível 2 | Outros 11
1122507 | Nível 2 | Outros 11
1122560 | Nível 2 | Outros 11
1122625 | Nível 2 | Outros 11
1123086 | Nível 2 | Outros 12
1123105 | Nível 2 | Outros 12
1123117 | Nível 2 | Outros 12
1123155 | Nível 2 | Outros 12
1123638 | Nível 2 | Outros 13
1123698 | Nível 2 | Outros 13
1123710 | Nível 2 | Outros 13

# IfcFlowFitting: Cotovelo - Soldado - CU:Padrão (247)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Padrão; sets with these values: 2
Name (Cotovelo - Soldado - CU:Padrão:...) | In | Group
1087866 | Nível 1 | Fornecimento hidrônico 2
1087985 | Nível 1 | Fornecimento hidrônico 2
1088005 | Nível 1 | Fornecimento hidrônico 2
1088365 | Nível 1 | Outros 2
1088378 | Nível 1 | Outros 2
1088380 | Nível 1 | Outros 2
1088499 | Nível 1 | Fornecimento hidrônico 2
1088713 | Nível 1 | Outros 2
1088715 | Nível 1 | Outros 2
1089028 | Nível 1 | Outros 2
1089030 | Nível 1 | Outros 2
1089055 | Nível 1 | Fornecimento hidrônico 2
1089060 | Nível 1 | Fornecimento hidrônico 2
1089317 | Nível 1 | Outros 2
1089325 | Nível 1 | Outros 2
1089327 | Nível 1 | Outros 2
1089555 | Nível 1 | Fornecimento hidrônico 2
1089597 | Nível 1 | Fornecimento hidrônico 2
1090195 | Nível 1 | Fornecimento hidrônico 1
1090458 | Nível 1 | Fornecimento hidrônico 1
1090499 | Nível 1 | Fornecimento hidrônico 2
1090547 | Nível 1 | Fornecimento hidrônico 2
1090816 | Nível 1 | Fornecimento hidrônico 1
1090820 | Nível 1 | Fornecimento hidrônico 1
1090850 | Nível 1 | Fornecimento hidrônico 2
1090944 | Nível 1 | Fornecimento hidrônico 2
1090946 | Nível 1 | Fornecimento hidrônico 2
1091004 | Nível 1 | Fornecimento hidrônico 1
1091057 | Nível 1 | Fornecimento hidrônico 1
1091216 | Nível 1 | Fornecimento hidrônico 2
1091385 | Nível 1 | Fornecimento hidrônico 1
1091600 | Nível 1 | Fornecimento hidrônico 1
1091690 | Nível 1 | Fornecimento hidrônico 1
1091851 | Nível 1 | Fornecimento hidrônico 1
1091884 | Nível 1 | Fornecimento hidrônico 2
1091933 | Nível 1 | Fornecimento hidrônico 2
1091937 | Nível 1 | Fornecimento hidrônico 2
1091986 | Nível 1 | Fornecimento hidrônico 1
1091990 | Nível 1 | Fornecimento hidrônico 1
1092009 | Nível 1 | Fornecimento hidrônico 2
1092037 | Nível 1 | Fornecimento hidrônico 2
1092041 | Nível 1 | Fornecimento hidrônico 2
1092338 | Nível 1 | Fornecimento hidrônico 1
1092387 | Nível 1 | Fornecimento hidrônico 1
1092459 | Nível 1 | Fornecimento hidrônico 1
1092506 | Nível 1 | Fornecimento hidrônico 2
1092578 | Nível 1 | Fornecimento hidrônico 2
1092737 | Nível 1 | Fornecimento hidrônico 1
1092847 | Nível 1 | Fornecimento hidrônico 1
1092958 | Nível 1 | Fornecimento hidrônico 1
1092975 | Nível 1 | Fornecimento hidrônico 1
1093039 | Nível 1 | Fornecimento hidrônico 1
1093049 | Nível 1 | Fornecimento hidrônico 1
1093323 | Nível 1 | Fornecimento hidrônico 2
1093333 | Nível 1 | Fornecimento hidrônico 2
1093698 | Nível 1 | Fornecimento hidrônico 2
1093727 | Nível 1 | Fornecimento hidrônico 2
1093731 | Nível 1 | Fornecimento hidrônico 2
1094752 | Nível 1 | Fornecimento hidrônico 2
1094760 | Nível 1 | Fornecimento hidrônico 2
1094762 | Nível 1 | Fornecimento hidrônico 2
1094823 | Nível 1 | Fornecimento hidrônico 2
1094927 | Nível 1 | Fornecimento hidrônico 2
1094939 | Nível 1 | Fornecimento hidrônico 2
1094988 | Nível 1 | Fornecimento hidrônico 2
1095003 | Nível 1 | Fornecimento hidrônico 2
1095007 | Nível 1 | Fornecimento hidrônico 2
1095011 | Nível 1 | Fornecimento hidrônico 2
1095190 | Nível 1 | Fornecimento hidrônico 1
1095277 | Nível 1 | Fornecimento hidrônico 1
1095316 | Nível 1 | Fornecimento hidrônico 1
1095324 | Nível 1 | Fornecimento hidrônico 1
1095336 | Nível 1 | Fornecimento hidrônico 1
1095410 | Nível 1 | Fornecimento hidrônico 1
1095468 | Nível 1 | Fornecimento hidrônico 1
1095478 | Nível 1 | Fornecimento hidrônico 1
1095488 | Nível 1 | Fornecimento hidrônico 1
1095532 | Nível 1 | Fornecimento hidrônico 1
1095553 | Nível 1 | Fornecimento hidrônico 1
1095597 | Nível 1 | Fornecimento hidrônico 1
1095623 | Nível 1 | Fornecimento hidrônico 2
1095661 | Nível 1 | Fornecimento hidrônico 1
1095669 | Nível 1 | Fornecimento hidrônico 1
1095793 | Nível 1 | Fornecimento hidrônico 1
1095807 | Nível 1 | Fornecimento hidrônico 1
1095836 | Nível 1 | Fornecimento hidrônico 1
1095840 | Nível 1 | Fornecimento hidrônico 1
1095855 | Nível 1 | Fornecimento hidrônico 1
1095857 | Nível 1 | Fornecimento hidrônico 1
1095874 | Nível 1 | Fornecimento hidrônico 1
1095876 | Nível 1 | Fornecimento hidrônico 1
1095915 | Nível 1 | Fornecimento hidrônico 1
1095987 | Nível 1 | Fornecimento hidrônico 1
1096046 | Nível 1 | Fornecimento hidrônico 1
1096066 | Nível 1 | Fornecimento hidrônico 1
1096083 | Nível 1 | Fornecimento hidrônico 1
1096094 | Nível 1 | Fornecimento hidrônico 1
1096121 | Nível 1 | Fornecimento hidrônico 1
1096125 | Nível 1 | Fornecimento hidrônico 1
1096331 | Nível 1 | Fornecimento hidrônico 1
1096345 | Nível 1 | Fornecimento hidrônico 1
1096540 | Nível 1 | Fornecimento hidrônico 2
1096602 | Nível 1 | Fornecimento hidrônico 2
1096606 | Nível 1 | Fornecimento hidrônico 2
1096763 | Nível 1 | Fornecimento hidrônico 1
1096802 | Nível 1 | Fornecimento hidrônico 1
1096806 | Nível 1 | Fornecimento hidrônico 1
1096916 | Nível 1 | Fornecimento hidrônico 1
1096931 | Nível 1 | Fornecimento hidrônico 1
1096941 | Nível 1 | Fornecimento hidrônico 1
1097034 | Nível 1 | Fornecimento hidrônico 2
1097044 | Nível 1 | Fornecimento hidrônico 2
1097056 | Nível 1 | Fornecimento hidrônico 2
1097341 | Nível 1 | Outros 2
1097500 | Nível 1 | Outros 2
1097506 | Nível 1 | Outros 2
1097510 | Nível 1 | Outros 2
1098318 | Nível 1 | Fornecimento hidrônico 2
1098337 | Nível 1 | Fornecimento hidrônico 2
1098341 | Nível 1 | Fornecimento hidrônico 2
1098345 | Nível 1 | Fornecimento hidrônico 2
1098469 | Nível 1 | Fornecimento hidrônico 1
1098581 | Nível 1 | Fornecimento hidrônico 1
1098717 | Nível 1 | Fornecimento hidrônico 1
1098995 | Nível 1 | Fornecimento hidrônico 1
1099084 | Nível 1 | Fornecimento hidrônico 1
1099264 | Nível 1 | Fornecimento hidrônico 1
1099272 | Nível 1 | Fornecimento hidrônico 1
1099274 | Nível 1 | Fornecimento hidrônico 1
1100240 | Nível 2 | Outros 3
1100248 | Nível 2 | Outros 3
1100562 | Nível 2 | Outros 3
1100564 | Nível 2 | Outros 3
1100618 | Nível 2 | Fornecimento hidrônico 2
1100626 | Nível 2 | Fornecimento hidrônico 2
1100636 | Nível 2 | Fornecimento hidrônico 2
1100669 | Nível 2 | Fornecimento hidrônico 2
1100970 | Nível 1 | Fornecimento hidrônico 1
1100999 | Nível 1 | Fornecimento hidrônico 2
1101018 | Nível 1 | Fornecimento hidrônico 2
1101023 | Nível 1 | Fornecimento hidrônico 2
1101027 | Nível 1 | Fornecimento hidrônico 2
1101919 | Nível 2 | Outros 3
1101924 | Nível 1 | Fornecimento hidrônico 1; Outros 3
1101966 | Nível 2 | Fornecimento hidrônico 2
1102060 | Nível 2 | Fornecimento hidrônico 2
1102300 | Nível 1 | Fornecimento hidrônico 2
1102302 | Nível 1 | Fornecimento hidrônico 2
1102339 | Nível 1 | Fornecimento hidrônico 2
1102343 | Nível 1 | Fornecimento hidrônico 2
1102660 | Nível 1 | Fornecimento hidrônico 1
1103821 | Nível 2 | Outros 4
1103834 | Nível 2 | Outros 4
1104002 | Nível 2 | Outros 5
1104087 | Nível 2 | Outros 5
1104130 | Nível 2 | Outros 6
1104213 | Nível 2 | Outros 6
1104240 | Nível 2 | Outros 4
1104342 | Nível 2 | Retorno hidrônico 1
1104357 | Nível 2 | Retorno hidrônico 1
1104373 | Nível 2 | Retorno hidrônico 1
1104528 | Nível 2 | Retorno hidrônico 2
1104651 | Nível 2 | Outros 4
1104838 | Nível 2 | Outros 4
1104873 | Nível 2 | Outros 6
1104966 | Nível 2 | Outros 6
1105005 | Nível 2 | Outros 4
1105069 | Nível 2 | Outros 6
1105498 | Nível 2 | Retorno hidrônico 2
1105500 | Nível 2 | Retorno hidrônico 2
1105549 | Nível 2 | Outros 6
1105765 | Nível 2 | Outros 4
1105767 | Nível 2 | Outros 4
1106137 | Nível 2 | Outros 6
1106139 | Nível 2 | Outros 6
1106399 | Nível 2 | Outros 4
1106433 | Nível 2 | Outros 4
1106759 | Nível 2 | Outros 8
1106829 | Nível 2 | Outros 8
1106980 | Nível 2 | Outros 6
1107076 | Nível 2 | Outros 6
1107176 | Nível 2 | Outros 4
1107480 | Nível 2 | Outros 4
1107574 | Nível 2 | Outros 4
1107673 | Nível 2 | Outros 6
1107677 | Nível 2 | Outros 6
1107718 | Nível 2 | Outros 4
1107850 | Nível 2 | Outros 4
1107885 | Nível 2 | Outros 6
1107994 | Nível 2 | Outros 6
1108161 | Nível 2 | Outros 4
1108208 | Nível 2 | Outros 6
1108248 | Nível 2 | Outros 6
1108262 | Nível 2 | Outros 6
1108279 | Nível 2 | Outros 4
1108299 | Nível 2 | Outros 4
1108600 | Nível 2 | Outros 4
1108684 | Nível 2 | Outros 6
1108785 | Nível 2 | Outros 4
1109178 | Nível 2 | Outros 6
1109188 | Nível 2 | Outros 6
1109235 | Nível 2 | Outros 6
1109925 | Nível 2 | Outros 4
1109933 | Nível 2 | Outros 4
1109949 | Nível 2 | Outros 4
1110002 | Nível 2 | Outros 6
1110010 | Nível 2 | Outros 6
1110032 | Nível 2 | Outros 6
1110395 | Nível 2 | Outros 4
1110397 | Nível 2 | Outros 4
1110534 | Nível 2 | Outros 4
1110560 | Nível 2 | Outros 4
1110786 | Nível 2 | Outros 6
1110788 | Nível 2 | Outros 6
1111005 | Nível 2 | Outros 4
1111180 | Nível 2 | Outros 4
1111211 | Nível 2 | Outros 4
1111266 | Nível 2 | Outros 6
1111268 | Nível 2 | Outros 6
1111299 | Nível 2 | Outros 6
1111301 | Nível 2 | Outros 6
1111358 | Nível 2 | Outros 6
1111368 | Nível 2 | Outros 6
1111376 | Nível 2 | Outros 6
1111402 | Nível 2 | Outros 6
1111407 | Nível 2 | Outros 6
1111411 | Nível 2 | Outros 6
1111802 | Nível 2 | Outros 4
1111844 | Nível 2 | Outros 6
1112933 | Nível 2 | Outros 4
1112966 | Nível 2 | Outros 4
1113055 | Nível 2 | Outros 6
1113057 | Nível 2 | Outros 6
1113273 | Nível 2 | Outros 4
1113507 | Nível 2 | Outros 4
1113608 | Nível 2 | Outros 6
1114101 | Nível 2 | Outros 6
1114736 | Nível 2 | Outros 4
1114746 | Nível 2 | Outros 4
1114766 | Nível 2 | Outros 4
1114801 | Nível 2 | Outros 6
1114813 | Nível 2 | Outros 6
1114833 | Nível 2 | Outros 6
1115002 | Nível 2 | Outros 6
1115063 | Nível 2 | Outros 4
1115123 | Nível 2 | Outros 6
1115179 | Nível 2 | Outros 4

# IfcFlowFitting: M_Capa de extremidade redonda:Padrão (4)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Padrão; sets with these values: 2
Name (M_Capa de extremidade redonda:Padrão:...) | In | Group
1007417 | Nível 1 | Mecânica Ar de fornecimento 14
1007426 | Nível 2 | Mecânica Ar de fornecimento 13
1007434 | Nível 2 | Mecânica Ar de fornecimento 13
1007442 | Nível 2 | Mecânica Ar de fornecimento 14

# IfcFlowFitting: M_Cotovelo redondo:2 D (33)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 2 D; sets with these values: 2
Name (M_Cotovelo redondo:2 D:...) | In | Group
996384 | Nível 1 | Mecânica Ar de fornecimento 1
998824 | Nível 1 | Mecânica Ar de fornecimento 4
999053 | Nível 1 | Mecânica Ar de fornecimento 3
1001490 | Nível 1 | Mecânica Ar de fornecimento 10
1001577 | Nível 1 | Mecânica Ar de fornecimento 10
1001658 | Nível 1 | Mecânica Ar de fornecimento 10
1001668 | Nível 1 | Mecânica Ar de fornecimento 10
1002028 | Nível 1 | Mecânica Ar de fornecimento 11
1002259 | Nível 1 | Mecânica Ar de fornecimento 12
1002269 | Nível 1 | Mecânica Ar de fornecimento 12
1002299 | Nível 1 | Mecânica Ar de fornecimento 12
1002311 | Nível 1 | Mecânica Ar de fornecimento 12
1003032 | Nível 1 | Mecânica Ar de fornecimento 3
1003332 | Nível 2 | Mecânica Ar de fornecimento 14
1003340 | Nível 2 | Mecânica Ar de fornecimento 14
1004438 | Nível 2 | Mecânica Ar de fornecimento 13
1005258 | Nível 1 | Mecânica Ar de fornecimento 13
1005348 | Nível 1 | Mecânica Ar de fornecimento 14
1005353 | Nível 1 | Mecânica Ar de fornecimento 14
1005772 | Nível 1 | Mecânica Ar de fornecimento 14
1005776 | Nível 1 | Mecânica Ar de fornecimento 14
1006062 | Nível 2 | Mecânica Ar de fornecimento 14
1006087 | Nível 1 | Mecânica Ar de fornecimento 14
1006459 | Nível 1 | Mecânica Ar de fornecimento 14
1006655 | Nível 1 | Mecânica Ar de fornecimento 14
1007264 | Nível 1 | Mecânica Ar de fornecimento 17
1007371 | Nível 1 | Mecânica Ar de fornecimento 14
1007379 | Nível 1 | Mecânica Ar de fornecimento 14
1045534 | Nível 1 | Mecânica Ar de fornecimento 17
1085399 | Nível 2 | Mecânica Ar de fornecimento 13
1085419 | Nível 2 | Mecânica Ar de fornecimento 13
1085423 | Nível 2 | Mecânica Ar de fornecimento 13
1085427 | Nível 2 | Mecânica Ar de fornecimento 13

# IfcFlowFitting: M_Encaixe de duto redondo:Padrão (26)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Padrão; sets with these values: 2
Name (M_Encaixe de duto redondo:Padrão:...) | In | Group
996381 | Nível 1 | Mecânica Ar de fornecimento 1
998821 | Nível 1 | Mecânica Ar de fornecimento 4
999050 | Nível 1 | Mecânica Ar de fornecimento 3
1001691 | Nível 1 | Mecânica Ar de fornecimento 9
1001709 | Nível 1 | Mecânica Ar de fornecimento 9
1003427 | Nível 2 | Mecânica Ar de fornecimento 13
1003500 | Nível 2 | Mecânica Ar de fornecimento 13
1003527 | Nível 2 | Mecânica Ar de fornecimento 13
1004474 | Nível 1 | Mecânica Ar de fornecimento 13; Mecânica Ar de fornecimento 15
1006085 | Nível 1 | Mecânica Ar de fornecimento 14; Mecânica Ar de fornecimento 17
1006272 | Nível 1 | Mecânica Ar de fornecimento 14
1007552 | Nível 2 | Mecânica Ar de fornecimento 14
1007569 | Nível 2 | Mecânica Ar de fornecimento 14
1007720 | Nível 2 | Mecânica Ar de fornecimento 14
1007821 | Nível 2 | Mecânica Ar de fornecimento 14
1007845 | Nível 2 | Mecânica Ar de fornecimento 17
1008063 | Nível 2 | Mecânica Ar de fornecimento 14
1082582 | Nível 1 | Mecânica Ar de fornecimento 14
1085417 | Nível 2 | Mecânica Ar de fornecimento 13
1102711 | Nível 1 | Mecânica Ar de fornecimento 9
1125062 | Nível 1 | Mecânica Ar de fornecimento 12
1125082 | Nível 1 | Mecânica Ar de fornecimento 11
1125089 | Nível 1 | Mecânica Ar de fornecimento 11
1125092 | Nível 1 | Mecânica Ar de fornecimento 11
1127469 | Nível 1 | Mecânica Ar de fornecimento 12
1127472 | Nível 1 | Mecânica Ar de fornecimento 12

# IfcFlowFitting: M_Encaixe de duto retangular:Padrão (55)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Padrão; sets with these values: 2
Name (M_Encaixe de duto retangular:Padrão:...) | In | Group
997988 | Nível 1 | Mecânica Ar de fornecimento 1
998011 | Nível 1 | Mecânica Ar de fornecimento 1
998018 | Nível 1 | Mecânica Ar de fornecimento 1
998037 | Nível 1 | Mecânica Ar de fornecimento 1
998048 | Nível 1 | Mecânica Ar de fornecimento 1
998071 | Nível 1 | Mecânica Ar de fornecimento 1
998086 | Nível 1 | Mecânica Ar de fornecimento 1
998116 | Nível 1 | Mecânica Ar de fornecimento 1
998127 | Nível 1 | Mecânica Ar de fornecimento 1
998215 | Nível 1 | Mecânica Ar de fornecimento 3
998237 | Nível 1 | Mecânica Ar de fornecimento 3
998248 | Nível 1 | Mecânica Ar de fornecimento 3
998259 | Nível 1 | Mecânica Ar de fornecimento 3
998274 | Nível 1 | Mecânica Ar de fornecimento 3
998297 | Nível 1 | Mecânica Ar de fornecimento 4
998312 | Nível 1 | Mecânica Ar de fornecimento 4
998342 | Nível 1 | Mecânica Ar de fornecimento 4
998364 | Nível 1 | Mecânica Ar de fornecimento 4
998962 | Nível 1 | Mecânica Ar de fornecimento 3
998974 | Nível 1 | Mecânica Ar de fornecimento 3
998993 | Nível 1 | Mecânica Ar de fornecimento 4
999008 | Nível 1 | Mecânica Ar de fornecimento 4
1001828 | Nível 1 | Mecânica Ar de fornecimento 10
1001835 | Nível 1 | Mecânica Ar de fornecimento 10
1001850 | Nível 1 | Mecânica Ar de fornecimento 10
1001904 | Nível 1 | Mecânica Ar de fornecimento 9
1001919 | Nível 1 | Mecânica Ar de fornecimento 9
1001938 | Nível 1 | Mecânica Ar de fornecimento 9
1003577 | Nível 2 | Mecânica Ar de fornecimento 13
1003615 | Nível 2 | Mecânica Ar de fornecimento 13
1003634 | Nível 2 | Mecânica Ar de fornecimento 13
1003817 | Nível 2 | Mecânica Ar de fornecimento 14
1003846 | Nível 2 | Mecânica Ar de fornecimento 14
1003861 | Nível 2 | Mecânica Ar de fornecimento 14
1004616 | Nível 1 | Mecânica Ar de fornecimento 13
1004661 | Nível 2 | Mecânica Ar de fornecimento 13
1004676 | Nível 2 | Mecânica Ar de fornecimento 13
1004691 | Nível 2 | Mecânica Ar de fornecimento 13
1005941 | Nível 1 | Mecânica Ar de fornecimento 14
1006231 | Nível 1 | Mecânica Ar de fornecimento 14
1006240 | Nível 1 | Mecânica Ar de fornecimento 14
1007465 | Nível 1 | Mecânica Ar de fornecimento 17
1007474 | Nível 1 | Mecânica Ar de fornecimento 17
1007606 | Nível 2 | Mecânica Ar de fornecimento 14
1007621 | Nível 2 | Mecânica Ar de fornecimento 14
1008023 | Nível 2 | Mecânica Ar de fornecimento 17
1008038 | Nível 2 | Mecânica Ar de fornecimento 14
1008086 | Nível 2 | Mecânica Ar de fornecimento 14
1008124 | Nível 2 | Mecânica Ar de fornecimento 17
1125065 | Nível 1 | Mecânica Ar de fornecimento 12
1125084 | Nível 1 | Mecânica Ar de fornecimento 11
1125091 | Nível 1 | Mecânica Ar de fornecimento 11
1125094 | Nível 1 | Mecânica Ar de fornecimento 11
1127471 | Nível 1 | Mecânica Ar de fornecimento 12
1127474 | Nível 1 | Mecânica Ar de fornecimento 12

# IfcFlowFitting: M_Transição redonda - Ângulo:45 Graus (3)
In: Nível 1
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 45 Graus; sets with these values: 2
Name (M_Transição redonda - Ângulo:45 Graus:...) | Group
1125054 | Mecânica Ar de fornecimento 12
1125073 | Mecânica Ar de fornecimento 11
1127467 | Mecânica Ar de fornecimento 12

# IfcFlowFitting: Plugue - Soldado - CU:Padrão (2)
In: Nível 2
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Padrão; sets with these values: 2
Name (Plugue - Soldado - CU:Padrão:...)
1123343
1123729

# IfcFlowFitting: Tê - Soldado - CU:Padrão (123)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Padrão; sets with these values: 2
Name (Tê - Soldado - CU:Padrão:...) | In | Group
1089002 | Nível 1 | Outros 2
1089222 | Nível 1 | Outros 2
1089386 | Nível 1 | Fornecimento hidrônico 2
1089593 | Nível 1 | Fornecimento hidrônico 2
1090170 | Nível 1 | Fornecimento hidrônico 1
1090292 | Nível 1 | Fornecimento hidrônico 2
1090783 | Nível 1 | Fornecimento hidrônico 1
1090806 | Nível 1 | Fornecimento hidrônico 1
1090846 | Nível 1 | Fornecimento hidrônico 2
1090930 | Nível 1 | Fornecimento hidrônico 2
1091033 | Nível 1 | Fornecimento hidrônico 1
1091251 | Nível 1 | Fornecimento hidrônico 2
1091360 | Nível 1 | Fornecimento hidrônico 1
1091519 | Nível 1 | Fornecimento hidrônico 2
1091975 | Nível 1 | Fornecimento hidrônico 1
1092026 | Nível 1 | Fornecimento hidrônico 2
1092327 | Nível 1 | Fornecimento hidrônico 1
1092635 | Nível 1 | Fornecimento hidrônico 1
1092739 | Nível 1 | Fornecimento hidrônico 1
1092851 | Nível 1 | Fornecimento hidrônico 1
1093029 | Nível 1 | Fornecimento hidrônico 1
1093294 | Nível 1 | Fornecimento hidrônico 2
1093717 | Nível 1 | Fornecimento hidrônico 2
1094825 | Nível 1 | Fornecimento hidrônico 2
1094875 | Nível 1 | Fornecimento hidrônico 2
1094879 | Nível 1 | Fornecimento hidrônico 2
1095826 | Nível 1 | Fornecimento hidrônico 1
1095963 | Nível 1 | Fornecimento hidrônico 1
1095977 | Nível 1 | Fornecimento hidrônico 1
1096056 | Nível 1 | Fornecimento hidrônico 1
1096110 | Nível 1 | Fornecimento hidrônico 1
1097183 | Nível 1 | Fornecimento hidrônico 2
1097321 | Nível 1 | Outros 2
1097496 | Nível 1 | Outros 2; Fornecimento hidrônico 1
1102325 | Nível 1 | Fornecimento hidrônico 2
1102664 | Nível 1 | Fornecimento hidrônico 1
1104518 | Nível 2 | Outros 5; Retorno hidrônico 2
1104995 | Nível 2 | Outros 4
1105059 | Nível 2 | Outros 6
1105107 | Nível 2 | Outros 4
1105140 | Nível 2 | Outros 6
1105191 | Nível 2 | Outros 4
1105235 | Nível 2 | Outros 6
1105330 | Nível 2 | Outros 4
1105366 | Nível 2 | Outros 6
1105484 | Nível 2 | Outros 4
1105525 | Nível 2 | Outros 6
1105539 | Nível 2 | Outros 6
1106032 | Nível 2 | Outros 4
1106042 | Nível 2 | Outros 4
1106218 | Nível 2 | Outros 6
1106222 | Nível 2 | Outros 6
1106423 | Nível 2 | Outros 4
1106480 | Nível 2 | Outros 6
1107149 | Nível 2 | Outros 8
1107166 | Nível 2 | Outros 4
1107404 | Nível 2 | Outros 6
1107414 | Nível 2 | Outros 6
1108128 | Nível 2 | Outros 4
1108151 | Nível 2 | Outros 4
1108182 | Nível 2 | Outros 6
1108198 | Nível 2 | Outros 6
1108258 | Nível 2 | Outros 6
1108289 | Nível 2 | Outros 4
1108767 | Nível 2 | Outros 4
1108775 | Nível 2 | Outros 4
1108932 | Nível 2 | Outros 6
1108936 | Nível 2 | Outros 6
1109945 | Nível 2 | Outros 4
1110022 | Nível 2 | Outros 6
1110414 | Nível 2 | Outros 4
1110562 | Nível 2 | Outros 4
1110829 | Nível 2 | Outros 6
1111201 | Nível 2 | Outros 4
1111290 | Nível 2 | Outros 6
1111398 | Nível 2 | Outros 6
1111804 | Nível 2 | Outros 4
1111846 | Nível 2 | Retorno hidrônico 1
1113095 | Nível 2 | Outros 4
1113665 | Nível 2 | Outros 4
1113868 | Nível 2 | Outros 6
1113985 | Nível 2 | Outros 6
1114720 | Nível 2 | Outros 4
1114756 | Nível 2 | Outros 4
1114784 | Nível 2 | Outros 6
1114823 | Nível 2 | Outros 6
1114973 | Nível 2 | Outros 6
1115004 | Nível 2 | Outros 6
1115065 | Nível 2 | Outros 4
1119431 | Nível 1 | Fornecimento hidrônico 4; Outros 7
1119450 | Nível 1 | Fornecimento hidrônico 5; Outros 7
1119666 | Nível 1 | Fornecimento hidrônico 6; Outros 9
1119704 | Nível 1 | Fornecimento hidrônico 8; Outros 9
1119720 | Nível 1 | Outros 9
1119907 | Nível 1 | Fornecimento hidrônico 10; Outros 9
1119999 | Nível 1 | Fornecimento hidrônico 11; Outros 9
1120288 | Nível 1 | Fornecimento hidrônico 9; Outros 9
1120484 | Nível 1 | Fornecimento hidrônico 14; Outros 10
1120502 | Nível 1 | Fornecimento hidrônico 15; Outros 10
1120520 | Nível 1 | Fornecimento hidrônico 16; Outros 10
1120648 | Nível 1 | Fornecimento hidrônico 18; Outros 10
1122582 | Nível 2 | Fornecimento hidrônico 22; Outros 11
1122600 | Nível 2 | Fornecimento hidrônico 23; Outros 11
1122702 | Nível 2 | Fornecimento hidrônico 24; Outros 11
1122720 | Nível 2 | Fornecimento hidrônico 25; Outros 11
1122750 | Nível 2 | Fornecimento hidrônico 27; Outros 11
1122766 | Nível 2 | Fornecimento hidrônico 28; Outros 11
1123245 | Nível 2 | Fornecimento hidrônico 30; Outros 12
1123269 | Nível 2 | Fornecimento hidrônico 31; Outros 12
1123289 | Nível 2 | Fornecimento hidrônico 32; Outros 12
1123309 | Nível 2 | Fornecimento hidrônico 33; Outros 12
1123327 | Nível 2 | Fornecimento hidrônico 34; Outros 12
1123349 | Nível 2 | Fornecimento hidrônico 35; Outros 12
1123369 | Nível 2 | Fornecimento hidrônico 36; Outros 12
1123387 | Nível 2 | Fornecimento hidrônico 37; Outros 12
1123405 | Nível 2 | Fornecimento hidrônico 38; Outros 12
1123423 | Nível 2 | Fornecimento hidrônico 39; Outros 12
1123494 | Nível 2 | Fornecimento hidrônico 40; Outros 12
1123512 | Nível 2 | Fornecimento hidrônico 41; Outros 12
1123735 | Nível 2 | Fornecimento hidrônico 42; Outros 13
1123753 | Nível 2 | Fornecimento hidrônico 43; Outros 13
1124090 | Nível 2 | Fornecimento hidrônico 46; Outros 12
1124110 | Nível 2 | Fornecimento hidrônico 47; Outros 12

# IfcFlowFitting: Tê de redução - PVC - CW:Padrão (6)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: Padrão; sets with these values: 2
Name (Tê de redução - PVC - CW:Padrão:...) | In | Group
1120022 | Nível 1 | Outros 9
1120085 | Nível 1 | Outros 9
1120849 | Nível 1 | Outros 10
1120914 | Nível 1 | Outros 10
1120976 | Nível 1 | Outros 10
1123927 | Nível 2 | Outros 12

# IfcFlowSegment: Duto redondo:Torneiras / Raio curto (83)
Pset_DistributionFlowElementCommon - Reference: Torneiras / Raio curto; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Duto redondo:Torneiras / Raio curto:...) | In | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
995796 | Nível 1 | 20850.4 | Mecânica Ar de fornecimento 1
996073 | Nível 1 | 20900 | Mecânica Ar de fornecimento 1
996113 | Nível 1 | 19777.3 | Mecânica Ar de fornecimento 3
996141 | Nível 1 | 20000 | Mecânica Ar de fornecimento 4
996167 | Nível 1 | 9840 | Mecânica Ar de fornecimento 3
996294 | Nível 1 | 8361.57 | Mecânica Ar de fornecimento 4
996326 | Nível 1 | 7238.88 | Mecânica Ar de fornecimento 1
996354 | Nível 1 | 700 | Mecânica Ar de fornecimento 1
996368 | Nível 1 | 1039 | Mecânica Ar de fornecimento 1
998495 | Nível 1 | 3900 | Mecânica Ar de fornecimento 3
998515 | Nível 1 | 580 | Mecânica Ar de fornecimento 3
998745 | Nível 1 | 90 | Mecânica Ar de fornecimento 4
998809 | Nível 1 | 3.69971 | Mecânica Ar de fornecimento 4
998860 | Nível 1 | 3600 | Mecânica Ar de fornecimento 4
999038 | Nível 1 | 1387.55 | Mecânica Ar de fornecimento 3
1001097 | Nível 1 | 6700 | Mecânica Ar de fornecimento 9
1001279 | Nível 1 | 9100 | Mecânica Ar de fornecimento 9
1001355 | Nível 1 | 390 | Mecânica Ar de fornecimento 10
1001482 | Nível 1 | 780 | Mecânica Ar de fornecimento 10
1001567 | Nível 1 | 7131.64 | Mecânica Ar de fornecimento 10
1001584 | Nível 1 | 2690 | Mecânica Ar de fornecimento 10
1001648 | Nível 1 | 80 | Mecânica Ar de fornecimento 10
1001660 | Nível 1 | 790 | Mecânica Ar de fornecimento 10
1001683 | Nível 1 | 1120.9 | Mecânica Ar de fornecimento 9
1001701 | Nível 1 | 1120.9 | Mecânica Ar de fornecimento 9
1001718 | Nível 1 | 1545.26 | Mecânica Ar de fornecimento 9
1002007 | Nível 1 | 598.793 | Mecânica Ar de fornecimento 11
1002019 | Nível 1 | 800 | Mecânica Ar de fornecimento 11
1002047 | Nível 1 | 7298.79 | Mecânica Ar de fornecimento 11
1002200 | Nível 1 | 133.087 | Mecânica Ar de fornecimento 12
1002249 | Nível 1 | 300 | Mecânica Ar de fornecimento 12
1002261 | Nível 1 | 1200 | Mecânica Ar de fornecimento 12
1002283 | Nível 1 | 2898.79 | Mecânica Ar de fornecimento 12
1002293 | Nível 1 | 3800 | Mecânica Ar de fornecimento 12
1002301 | Nível 1 | 4400 | Mecânica Ar de fornecimento 12
1002329 | Nível 1 | 1798.4 | Mecânica Ar de fornecimento 11
1002354 | Nível 1 | 1798.4 | Mecânica Ar de fornecimento 11
1002405 | Nível 1 | 1397.9 | Mecânica Ar de fornecimento 11
1002425 | Nível 1 | 1398.4 | Mecânica Ar de fornecimento 12
1002443 | Nível 1 | 1097.9 | Mecânica Ar de fornecimento 12
1002462 | Nível 1 | 1898.4 | Mecânica Ar de fornecimento 12
1003022 | Nível 1 | 3200 | Mecânica Ar de fornecimento 3
1003216 | Nível 2 | 18000 | Mecânica Ar de fornecimento 13
1003260 | Nível 2 | 5000 | Mecânica Ar de fornecimento 13
1003286 | Nível 2 | 1300 | Mecânica Ar de fornecimento 14
1003312 | Nível 2 | 80 | Mecânica Ar de fornecimento 14
1003324 | Nível 2 | 400 | Mecânica Ar de fornecimento 14
1003334 | Nível 2 | 20020 | Mecânica Ar de fornecimento 14
1003416 | Nível 2 | 1398.4 | Mecânica Ar de fornecimento 13
1003498 | Nível 2 | 1398.4 | Mecânica Ar de fornecimento 13
1003525 | Nível 2 | 1398.4 | Mecânica Ar de fornecimento 13
1004301 | Nível 2 | 2674.74 | Mecânica Ar de fornecimento 13
1004358 | Nível 2 | 15500 | Mecânica Ar de fornecimento 13; Mecânica Ar de fornecimento 15
1004428 | Nível 1 | 5500 | Mecânica Ar de fornecimento 13
1004754 | Nível 2 | 460 | Mecânica Ar de fornecimento 14
1005187 | Nível 1 | 27440 | Mecânica Ar de fornecimento 13
1005201 | Nível 2 | 2185.64 | Mecânica Ar de fornecimento 13
1005293 | Nível 1 | 3500 | Mecânica Ar de fornecimento 14
1005299 | Nível 1 | 6468.63 | Mecânica Ar de fornecimento 14; Mecânica Ar de fornecimento 17
1005335 | Nível 1 | 2036.26 | Mecânica Ar de fornecimento 14
1005346 | Nível 1 | 45.7793 | Mecânica Ar de fornecimento 14
1005761 | Nível 1 | 2988.28 | Mecânica Ar de fornecimento 14
1005770 | Nível 1 | 45.7793 | Mecânica Ar de fornecimento 14
1006077 | Nível 1 | 164.899 | Mecânica Ar de fornecimento 14
1006169 | Nível 1 | 16747.8 | Mecânica Ar de fornecimento 14
1006635 | Nível 1 | 5000 | Mecânica Ar de fornecimento 14
1006649 | Nível 1 | 23300 | Mecânica Ar de fornecimento 14
1006842 | Nível 1 | 3933.63 | Mecânica Ar de fornecimento 14
1007229 | Nível 1 | 100 | Mecânica Ar de fornecimento 17
1007248 | Nível 1 | 67.5171 | Mecânica Ar de fornecimento 17
1007258 | Nível 1 | 21770.5 | Mecânica Ar de fornecimento 17
1007358 | Nível 1 | 721.177 | Mecânica Ar de fornecimento 14
1007373 | Nível 1 | 8790.58 | Mecânica Ar de fornecimento 14
1007544 | Nível 2 | 1098.4 | Mecânica Ar de fornecimento 14
1007561 | Nível 2 | 1098.4 | Mecânica Ar de fornecimento 14
1007813 | Nível 2 | 6698.4 | Mecânica Ar de fornecimento 14
1007837 | Nível 2 | 6498.4 | Mecânica Ar de fornecimento 17
1008055 | Nível 2 | 1398.4 | Mecânica Ar de fornecimento 14
1045528 | Nível 2 | 22700 | Mecânica Ar de fornecimento 17
1085381 | Nível 2 | 750.514 | Mecânica Ar de fornecimento 13
1085397 | Nível 2 | 171.281 | Mecânica Ar de fornecimento 13
1085413 | Nível 2 | 162.731 | Mecânica Ar de fornecimento 13
1085414 | Nível 2 | 171.281 | Mecânica Ar de fornecimento 13

# IfcFlowSegment: Duto retangular:Raios cotovelos / torneiras (55)
Pset_DistributionFlowElementCommon - Reference: Raios cotovelos / torneiras; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: RECTANGULAR
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Duto retangular:Raios cotovelos / torneiras:...) | In | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
997987 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 1
998010 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 1
998017 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 1
998036 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 1
998047 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 1
998070 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 1
998085 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 1
998115 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 1
998126 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 1
998214 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 3
998236 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 3
998247 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 3
998258 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 3
998273 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 3
998296 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 4
998311 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 4
998341 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 4
998363 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 4
998961 | Nível 1 | 224.3 | Mecânica Ar de fornecimento 3
998973 | Nível 1 | 224.3 | Mecânica Ar de fornecimento 3
998992 | Nível 1 | 224.3 | Mecânica Ar de fornecimento 4
999007 | Nível 1 | 224.3 | Mecânica Ar de fornecimento 4
1001827 | Nível 1 | 224.3 | Mecânica Ar de fornecimento 10
1001834 | Nível 1 | 224.3 | Mecânica Ar de fornecimento 10
1001849 | Nível 1 | 224.3 | Mecânica Ar de fornecimento 10
1001903 | Nível 1 | 224.3 | Mecânica Ar de fornecimento 9
1001918 | Nível 1 | 224.3 | Mecânica Ar de fornecimento 9
1001937 | Nível 1 | 226.738 | Mecânica Ar de fornecimento 9
1002488 | Nível 1 | 314.4 | Mecânica Ar de fornecimento 12
1002507 | Nível 1 | 314.4 | Mecânica Ar de fornecimento 12
1002518 | Nível 1 | 314.4 | Mecânica Ar de fornecimento 12
1002549 | Nível 1 | 314.4 | Mecânica Ar de fornecimento 11
1002564 | Nível 1 | 314.4 | Mecânica Ar de fornecimento 11
1002583 | Nível 1 | 314.4 | Mecânica Ar de fornecimento 11
1003576 | Nível 2 | 217.8 | Mecânica Ar de fornecimento 13
1003614 | Nível 2 | 217.8 | Mecânica Ar de fornecimento 13
1003633 | Nível 2 | 217.8 | Mecânica Ar de fornecimento 13
1003816 | Nível 2 | 217.8 | Mecânica Ar de fornecimento 14
1003845 | Nível 2 | 217.8 | Mecânica Ar de fornecimento 14
1003860 | Nível 2 | 217.8 | Mecânica Ar de fornecimento 14
1004615 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 13
1004660 | Nível 2 | 217.8 | Mecânica Ar de fornecimento 13
1004675 | Nível 2 | 217.8 | Mecânica Ar de fornecimento 13
1004690 | Nível 2 | 217.8 | Mecânica Ar de fornecimento 13
1005940 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 14
1006230 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 14
1006239 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 14
1007464 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 17
1007473 | Nível 1 | 217.8 | Mecânica Ar de fornecimento 17
1007605 | Nível 2 | 217.8 | Mecânica Ar de fornecimento 14
1007620 | Nível 2 | 217.8 | Mecânica Ar de fornecimento 14
1008022 | Nível 2 | 314.4 | Mecânica Ar de fornecimento 17
1008037 | Nível 2 | 314.4 | Mecânica Ar de fornecimento 14
1008085 | Nível 2 | 217.8 | Mecânica Ar de fornecimento 14
1008123 | Nível 2 | 217.8 | Mecânica Ar de fornecimento 17

# IfcFlowSegment: Tipos de tubos:Plástico (80)
Type - Material: Acabamento Azul
Pset_DistributionFlowElementCommon - Reference: Plástico; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Tipos de tubos:Plástico:...) | In | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
1119237 | Nível 1 | 8222.87 | Outros 7
1119359 | Nível 1 | 2450.45 | Outros 7
1119393 | Nível 1 | 3095.08 | Outros 7
1119400 | Nível 1 | 95 | Outros 7
1119432 | Nível 1 | 190.244 | Outros 7
1119451 | Nível 1 | 3811.58 | Outros 7
1119583 | Nível 1 | 6456.92 | Outros 9
1119667 | Nível 1 | 1092.87 | Outros 9
1119705 | Nível 1 | 2059.19 | Fornecimento hidrônico 7; Outros 9
1119721 | Nível 1 | 7953.3 | Outros 9
1119737 | Nível 1 | 444.272 | Outros 9
1119908 | Nível 1 | 484.492 | Outros 9
1119918 | Nível 1 | 1810.33 | Outros 9
1119942 | Nível 1 | 2959.83 | Outros 9
1120000 | Nível 1 | 429.389 | Outros 9
1120006 | Nível 1 | 3472.28 | Outros 9
1120018 | Nível 1 | 6.42398 | Outros 9
1120019 | Nível 1 | 12.3161 | Outros 9
1120023 | Nível 1 | 8693.24 | Outros 9
1120071 | Nível 1 | 2971.71 | Outros 9
1120081 | Nível 1 | 6.42398 | Outros 9
1120082 | Nível 1 | 123.83 | Outros 9
1120086 | Nível 1 | 3349.35 | Outros 9
1120289 | Nível 1 | 563.141 | Outros 9
1120295 | Nível 1 | 1259 | Outros 10
1120388 | Nível 1 | 410.256 | Outros 10
1120406 | Nível 1 | 3017.63 | Outros 10
1120413 | Nível 1 | 255 | Outros 10
1120485 | Nível 1 | 8512.2 | Outros 10
1120503 | Nível 1 | 1068.3 | Outros 10
1120521 | Nível 1 | 4711.53 | Outros 10
1120527 | Nível 1 | 425.123 | Outros 10
1120649 | Nível 1 | 1883.86 | Outros 10
1120841 | Nível 1 | 2180.11 | Outros 10
1120850 | Nível 1 | 584.077 | Outros 10
1120903 | Nível 1 | 1290.77 | Outros 10
1120912 | Nível 1 | 126.096 | Outros 10
1120915 | Nível 1 | 3011.8 | Outros 10
1120967 | Nível 1 | 3934.97 | Outros 10
1120974 | Nível 1 | 10.7689 | Outros 10
1120977 | Nível 1 | 1842.94 | Outros 10
1122235 | Nível 2 | 4066.31 | Outros 11
1122428 | Nível 2 | 331.334 | Outros 11
1122440 | Nível 2 | 2510 | Outros 11
1122448 | Nível 2 | 2075.01 | Outros 11
1122494 | Nível 2 | 65.0122 | Outros 11
1122495 | Nível 2 | 25.376 | Outros 11
1122583 | Nível 2 | 3599.03 | Outros 11
1122601 | Nível 2 | 848.758 | Outros 11
1122703 | Nível 2 | 4988.93 | Outros 11
1122721 | Nível 2 | 5795.5 | Outros 11
1122751 | Nível 2 | 4070.03 | Fornecimento hidrônico 26; Outros 11
1122767 | Nível 2 | 5209.27 | Outros 11
1122773 | Nível 2 | 375.971 | Outros 12
1123078 | Nível 2 | 910 | Outros 12
1123102 | Nível 2 | 2955.67 | Outros 12
1123109 | Nível 2 | 155 | Outros 12
1123137 | Nível 2 | 300.729 | Outros 12
1123149 | Nível 2 | 347.733 | Outros 12
1123246 | Nível 2 | 1180.63 | Outros 12
1123270 | Nível 2 | 1216.65 | Outros 12
1123290 | Nível 2 | 211.435 | Outros 12
1123310 | Nível 2 | 2314.68 | Outros 12
1123328 | Nível 2 | 2305.15 | Outros 12
1123370 | Nível 2 | 3498.77 | Outros 12
1123388 | Nível 2 | 2050.27 | Outros 12
1123406 | Nível 2 | 4000 | Outros 12
1123424 | Nível 2 | 6798.06 | Outros 12
1123495 | Nível 2 | 1375.19 | Outros 12
1123513 | Nível 2 | 4073.49 | Outros 12
1123529 | Nível 2 | 251.777 | Outros 13
1123582 | Nível 2 | 5802.2 | Outros 13
1123695 | Nível 2 | 3190.23 | Outros 13
1123702 | Nível 2 | 157.047 | Outros 13
1123736 | Nível 2 | 1026.79 | Outros 13
1123754 | Nível 2 | 4322 | Outros 13
1123919 | Nível 2 | 5070.68 | Outros 12
1123928 | Nível 2 | 1347.8 | Outros 12
1124091 | Nível 2 | 2448.08 | Outros 12
1124111 | Nível 2 | 2615.78 | Outros 12

# IfcFlowSegment: Tipos de tubos:Tubos de cobre HVAC (432)
Type - Material: Acabamento Azul
Pset_DistributionFlowElementCommon - Reference: Tubos de cobre HVAC; sets with these values: 2
Pset_DuctSegmentTypeCommon - Shape: ROUND
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Tipos de tubos:Tubos de cobre HVAC:...) | In | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
1087634 | Nível 1 | 1458.36 | Outros 2
1087682 | Nível 1 | 611.329 | Outros 2
1087844 | Nível 1 | 686.3 | Fornecimento hidrônico 2
1087858 | Nível 1 | 1098.92 | Fornecimento hidrônico 2
1087884 | Nível 1 | 1338.79 | Fornecimento hidrônico 2
1087983 | Nível 1 | 22.3873 | Fornecimento hidrônico 2
1087996 | Nível 1 | 60.4742 | Fornecimento hidrônico 2
1088210 | Nível 1 | 98.3654 | Outros 2
1088226 | Nível 1 | 5756.74 | Outros 2
1088294 | Nível 1 | 1271.02 | Outros 2
1088363 | Nível 1 | 12.0385 | Outros 2
1088406 | Nível 1 | 226.3 | Fornecimento hidrônico 2

Properties of the parts of a building model (IFC2X3), part 3 of 5

# IfcDistributionPort (3613)
Name | FlowDirection | Group
Port_1101027_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101003_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101023_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101003_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101027_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101016_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101018_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101016_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101023_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1101887_0 | SOURCEANDSINK | Outros 3
Port_1101919_2 | SOURCEANDSINK | Outros 3
Port_1101887_1 | SOURCEANDSINK | Outros 3
Port_1101924_2 | SOURCEANDSINK | Outros 3
Port_1101966_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102004_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102004_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102060_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102300_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102326_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102323_0 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102333_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102323_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102343_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102325_2 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102326_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102325_3 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102333_1 | SOURCEANDSINK | Fornecimento hidrônico 2
Port_1102648_0 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1102668_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1102664_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1102668_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1102664_2 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1102670_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1102665_1 | SOURCEANDSINK | Fornecimento hidrônico 1
Port_1102670_2 | SOURCEANDSINK | Fornecimento hidrônico 1
InPort_1102711_1 | SINK | Mecânica Ar de fornecimento 9
OutPort_1001279_4 | SOURCE | Mecânica Ar de fornecimento 9
Port_1102725_5 | SOURCEANDSINK | Fornecimento hidrônico 23
Port_1122597_0 | SOURCEANDSINK | Fornecimento hidrônico 23
InPort_1103985_1 | SINK | Outros 5
OutPort_1102725_6 | SOURCE | Outros 5
InPort_1104211_1 | SINK | Outros 6
OutPort_1102725_7 | SOURCE | Outros 6
Port_1102725_8 | SOURCEANDSINK
Port_1102736_5 | SOURCEANDSINK | Fornecimento hidrônico 22
Port_1122579_0 | SOURCEANDSINK | Fornecimento hidrônico 22
InPort_1104085_1 | SINK | Outros 5
OutPort_1102736_6 | SOURCE | Outros 5
InPort_1104116_1 | SINK | Outros 6
OutPort_1102736_7 | SOURCE | Outros 6
Port_1102736_8 | SOURCEANDSINK
Port_1102747_5 | SOURCEANDSINK | Fornecimento hidrônico 24
Port_1122699_0 | SOURCEANDSINK | Fornecimento hidrônico 24
InPort_1105340_2 | SINK | Outros 4
OutPort_1102747_6 | SOURCE | Outros 4
InPort_1105376_2 | SINK | Outros 6
OutPort_1102747_7 | SOURCE | Outros 6
Port_1102747_8 | SOURCEANDSINK
Port_1102847_5 | SOURCEANDSINK | Fornecimento hidrônico 25
Port_1122717_0 | SOURCEANDSINK | Fornecimento hidrônico 25
InPort_1105201_2 | SINK | Outros 4
OutPort_1102847_6 | SOURCE | Outros 4
InPort_1105246_2 | SINK | Outros 6
OutPort_1102847_7 | SOURCE | Outros 6
Port_1102847_8 | SOURCEANDSINK
Port_1102862_5 | SOURCEANDSINK | Fornecimento hidrônico 28
Port_1122763_0 | SOURCEANDSINK | Fornecimento hidrônico 28
InPort_1105117_2 | SINK | Outros 4
OutPort_1102862_6 | SOURCE | Outros 4
InPort_1105144_2 | SINK | Outros 6
OutPort_1102862_7 | SOURCE | Outros 6
Port_1102862_8 | SOURCEANDSINK
Port_1102865_5 | SOURCEANDSINK | Fornecimento hidrônico 27
Port_1122747_0 | SOURCEANDSINK | Fornecimento hidrônico 27
InPort_1104570_1 | SINK | Outros 4
OutPort_1102865_6 | SOURCE | Outros 4
InPort_1104865_1 | SINK | Outros 6
OutPort_1102865_7 | SOURCE | Outros 6
Port_1102865_8 | SOURCEANDSINK
Port_1102868_5 | SOURCEANDSINK | Fornecimento hidrônico 26
Port_1122735_0 | SOURCEANDSINK | Fornecimento hidrônico 26
InPort_1104836_1 | SINK | Outros 4
OutPort_1102868_6 | SOURCE | Outros 4
InPort_1104964_1 | SINK | Outros 6
OutPort_1102868_7 | SOURCE | Outros 6
Port_1102868_8 | SOURCEANDSINK
Port_1102912_5 | SOURCEANDSINK | Fornecimento hidrônico 45
Port_1124075_0 | SOURCEANDSINK | Fornecimento hidrônico 45
InPort_1113417_1 | SINK | Outros 4
OutPort_1102912_6 | SOURCE | Outros 4
InPort_1113588_1 | SINK | Outros 6
OutPort_1102912_7 | SOURCE | Outros 6
Port_1102912_8 | SOURCEANDSINK
Port_1102923_5 | SOURCEANDSINK | Fornecimento hidrônico 46
Port_1124087_0 | SOURCEANDSINK | Fornecimento hidrônico 46
InPort_1113505_1 | SINK | Outros 4
OutPort_1102923_6 | SOURCE | Outros 4
InPort_1113606_1 | SINK | Outros 6
OutPort_1102923_7 | SOURCE | Outros 6
Port_1102923_8 | SOURCEANDSINK
Port_1102937_5 | SOURCEANDSINK | Fornecimento hidrônico 35
Port_1123346_0 | SOURCEANDSINK | Fornecimento hidrônico 35
InPort_1115195_2 | SINK | Outros 4
OutPort_1102937_6 | SOURCE | Outros 4
InPort_1114089_1 | SINK | Outros 6
OutPort_1102937_7 | SOURCE | Outros 6
Port_1102937_8 | SOURCEANDSINK
Port_1103167_5 | SOURCEANDSINK | Fornecimento hidrônico 34
Port_1123324_0 | SOURCEANDSINK | Fornecimento hidrônico 34
InPort_1112968_2 | SINK | Outros 4
OutPort_1103167_6 | SOURCE | Outros 4
InPort_1113029_1 | SINK | Outros 6
OutPort_1103167_7 | SOURCE | Outros 6
Port_1103167_8 | SOURCEANDSINK
Port_1103181_5 | SOURCEANDSINK | Fornecimento hidrônico 33
Port_1123306_0 | SOURCEANDSINK | Fornecimento hidrônico 33
InPort_1112921_1 | SINK | Outros 4
OutPort_1103181_6 | SOURCE | Outros 4
InPort_1112989_1 | SINK | Outros 6
OutPort_1103181_7 | SOURCE | Outros 6
Port_1103181_8 | SOURCEANDSINK
Port_1103197_5 | SOURCEANDSINK | Fornecimento hidrônico 36
Port_1123366_0 | SOURCEANDSINK | Fornecimento hidrônico 36
InPort_1108598_1 | SINK | Outros 4
OutPort_1103197_6 | SOURCE | Outros 4
InPort_1108666_1 | SINK | Outros 6
OutPort_1103197_7 | SOURCE | Outros 6
Port_1103197_8 | SOURCEANDSINK
Port_1103214_5 | SOURCEANDSINK | Fornecimento hidrônico 29
Port_1123230_0 | SOURCEANDSINK | Fornecimento hidrônico 29
InPort_1107572_1 | SINK | Outros 4
OutPort_1103214_6 | SOURCE | Outros 4
InPort_1107601_1 | SINK | Outros 6
OutPort_1103214_7 | SOURCE | Outros 6
Port_1103214_8 | SOURCEANDSINK
Port_1103229_5 | SOURCEANDSINK | Fornecimento hidrônico 32
Port_1123286_0 | SOURCEANDSINK | Fornecimento hidrônico 32
InPort_1107708_1 | SINK | Outros 4
OutPort_1103229_6 | SOURCE | Outros 4
InPort_1107992_1 | SINK | Outros 6
OutPort_1103229_7 | SOURCE | Outros 6
Port_1103229_8 | SOURCEANDSINK
Port_1103244_5 | SOURCEANDSINK | Fornecimento hidrônico 31
Port_1123266_0 | SOURCEANDSINK | Fornecimento hidrônico 31
InPort_1107848_1 | SINK | Outros 4
OutPort_1103244_6 | SOURCE | Outros 4
InPort_1107875_1 | SINK | Outros 6
OutPort_1103244_7 | SOURCE | Outros 6
Port_1103244_8 | SOURCEANDSINK
Port_1103255_5 | SOURCEANDSINK | Fornecimento hidrônico 30
Port_1123242_0 | SOURCEANDSINK | Fornecimento hidrônico 30
InPort_1107470_1 | SINK | Outros 4
OutPort_1103255_6 | SOURCE | Outros 4
InPort_1107647_1 | SINK | Outros 6
OutPort_1103255_7 | SOURCE | Outros 6
Port_1103255_8 | SOURCEANDSINK
Port_1103276_5 | SOURCEANDSINK | Fornecimento hidrônico 40
Port_1123491_0 | SOURCEANDSINK | Fornecimento hidrônico 40
InPort_1106688_2 | SINK | Outros 8
OutPort_1103276_6 | SOURCE | Outros 8
InPort_1106894_1 | SINK | Outros 6
OutPort_1103276_7 | SOURCE | Outros 6
Port_1103276_8 | SOURCEANDSINK
Port_1103287_5 | SOURCEANDSINK | Fornecimento hidrônico 41
Port_1123509_0 | SOURCEANDSINK | Fornecimento hidrônico 41
InPort_1106827_1 | SINK | Outros 8
OutPort_1103287_6 | SOURCE | Outros 8
InPort_1107074_1 | SINK | Outros 6
OutPort_1103287_7 | SOURCE | Outros 6
Port_1103287_8 | SOURCEANDSINK
Port_1103298_5 | SOURCEANDSINK | Fornecimento hidrônico 39
Port_1123420_0 | SOURCEANDSINK | Fornecimento hidrônico 39
InPort_1106311_1 | SINK | Outros 4
OutPort_1103298_6 | SOURCE | Outros 4
InPort_1106490_2 | SINK | Outros 6
OutPort_1103298_7 | SOURCE | Outros 6
Port_1103298_8 | SOURCEANDSINK
Port_1103312_5 | SOURCEANDSINK | Fornecimento hidrônico 37
Port_1123384_0 | SOURCEANDSINK | Fornecimento hidrônico 37
InPort_1105693_1 | SINK | Outros 4
OutPort_1103312_6 | SOURCE | Outros 4
InPort_1105792_1 | SINK | Outros 6
OutPort_1103312_7 | SOURCE | Outros 6
Port_1103312_8 | SOURCEANDSINK
Port_1103323_5 | SOURCEANDSINK | Fornecimento hidrônico 38
Port_1123402_0 | SOURCEANDSINK | Fornecimento hidrônico 38
InPort_1105735_1 | SINK | Outros 4
OutPort_1103323_6 | SOURCE | Outros 4
InPort_1105874_1 | SINK | Outros 6
OutPort_1103323_7 | SOURCE | Outros 6
Port_1103323_8 | SOURCEANDSINK
Port_1103341_5 | SOURCEANDSINK | Fornecimento hidrônico 44
Port_1123873_0 | SOURCEANDSINK | Fornecimento hidrônico 44
InPort_1110988_1 | SINK | Outros 4
OutPort_1103341_6 | SOURCE | Outros 4
InPort_1111053_1 | SINK | Outros 6
OutPort_1103341_7 | SOURCE | Outros 6
Port_1103341_8 | SOURCEANDSINK
Port_1103355_5 | SOURCEANDSINK | Fornecimento hidrônico 42
Port_1123732_0 | SOURCEANDSINK | Fornecimento hidrônico 42
InPort_1110166_1 | SINK | Outros 4
OutPort_1103355_6 | SOURCE | Outros 4
InPort_1110317_1 | SINK | Outros 6
OutPort_1103355_7 | SOURCE | Outros 6
Port_1103355_8 | SOURCEANDSINK
Port_1103370_5 | SOURCEANDSINK | Fornecimento hidrônico 43
Port_1123750_0 | SOURCEANDSINK | Fornecimento hidrônico 43
InPort_1110210_1 | SINK | Outros 4
OutPort_1103370_6 | SOURCE | Outros 4
InPort_1110277_1 | SINK | Outros 6
OutPort_1103370_7 | SOURCE | Outros 6
Port_1103370_8 | SOURCEANDSINK
Port_1103384_5 | SOURCEANDSINK | Fornecimento hidrônico 47
Port_1124107_0 | SOURCEANDSINK | Fornecimento hidrônico 47
InPort_1108442_1 | SINK | Outros 4
OutPort_1103384_6 | SOURCE | Outros 4
InPort_1108682_1 | SINK | Outros 6
OutPort_1103384_7 | SOURCE | Outros 6
Port_1103384_8 | SOURCEANDSINK
Port_1103473_22 | SOURCEANDSINK
Port_1103473_23 | SOURCEANDSINK
Port_1103473_24 | SOURCEANDSINK
Port_1103473_25 | SOURCEANDSINK
Port_1103473_26 | SOURCEANDSINK
Port_1103473_27 | SOURCEANDSINK
Port_1103473_28 | SOURCEANDSINK
Port_1103473_29 | SOURCEANDSINK
Port_1103473_30 | SOURCEANDSINK
Port_1103473_31 | SOURCEANDSINK
Port_1103473_32 | SOURCEANDSINK
Port_1103473_33 | SOURCEANDSINK
Port_1103473_34 | SOURCEANDSINK
Port_1103473_35 | SOURCEANDSINK
Port_1103473_36 | SOURCEANDSINK | Retorno hidrônico 1
Port_1104322_0 | SOURCEANDSINK | Retorno hidrônico 1
InPort_1103798_0 | SINK | Outros 4
OutPort_1103473_37 | SOURCE | Outros 4
Port_1103798_1 | SOURCEANDSINK | Outros 4
Port_1103821_1 | SOURCEANDSINK | Outros 4
Port_1103812_0 | SOURCEANDSINK | Outros 4
Port_1103821_2 | SOURCEANDSINK | Outros 4
Port_1103812_1 | SOURCEANDSINK | Outros 4
Port_1103834_1 | SOURCEANDSINK | Outros 4
Port_1103831_0 | SOURCEANDSINK | Outros 4
Port_1104240_1 | SOURCEANDSINK | Outros 4
Port_1103831_1 | SOURCEANDSINK | Outros 4
Port_1103834_2 | SOURCEANDSINK | Outros 4
Port_1103971_0 | SOURCEANDSINK | Outros 5
Port_1103985_2 | SOURCEANDSINK | Outros 5
Port_1103971_1 | SOURCEANDSINK | Outros 5
Port_1104002_1 | SOURCEANDSINK | Outros 5
Port_1103987_0 | SOURCEANDSINK | Outros 5
Port_1104522_2 | SOURCEANDSINK | Outros 5
Port_1103987_1 | SOURCEANDSINK | Outros 5
Port_1104087_1 | SOURCEANDSINK | Outros 5
Port_1104002_2 | SOURCEANDSINK | Outros 5
Port_1104519_0 | SOURCEANDSINK | Outros 5
Port_1104020_0 | SOURCEANDSINK | Outros 5
Port_1104085_2 | SOURCEANDSINK | Outros 5
Port_1104020_1 | SOURCEANDSINK | Outros 5
Port_1104087_2 | SOURCEANDSINK | Outros 5
Port_1104102_0 | SOURCEANDSINK | Outros 6
Port_1104116_2 | SOURCEANDSINK | Outros 6
Port_1104102_1 | SOURCEANDSINK | Outros 6
Port_1104130_2 | SOURCEANDSINK | Outros 6
Port_1104118_0 | SOURCEANDSINK | Outros 6
Port_1105525_1 | SOURCEANDSINK | Outros 6
Port_1104118_1 | SOURCEANDSINK | Outros 6
Port_1104213_2 | SOURCEANDSINK | Outros 6
Port_1104130_1 | SOURCEANDSINK | Outros 6
Port_1105526_0 | SOURCEANDSINK | Outros 6
Port_1104151_0 | SOURCEANDSINK | Outros 6
Port_1104211_2 | SOURCEANDSINK | Outros 6
Port_1104151_1 | SOURCEANDSINK | Outros 6
Port_1104213_1 | SOURCEANDSINK | Outros 6
Port_1104240_2 | SOURCEANDSINK | Outros 4
Port_1111805_0 | SOURCEANDSINK | Outros 4
Port_1104322_1 | SOURCEANDSINK | Retorno hidrônico 1
Port_1104342_1 | SOURCEANDSINK | Retorno hidrônico 1
Port_1104334_0 | SOURCEANDSINK | Retorno hidrônico 1
Port_1104342_2 | SOURCEANDSINK | Retorno hidrônico 1
Port_1104334_1 | SOURCEANDSINK | Retorno hidrônico 1
Port_1104357_1 | SOURCEANDSINK | Retorno hidrônico 1
Port_1104354_0 | SOURCEANDSINK | Retorno hidrônico 1
Port_1104373_1 | SOURCEANDSINK | Retorno hidrônico 1
Port_1104354_1 | SOURCEANDSINK | Retorno hidrônico 1
Port_1104357_2 | SOURCEANDSINK | Retorno hidrônico 1
Port_1104373_2 | SOURCEANDSINK | Retorno hidrônico 1
Port_1111847_0 | SOURCEANDSINK | Retorno hidrônico 1
Port_1104497_0 | SOURCEANDSINK | Retorno hidrônico 2
Port_1114168_2 | SOURCEANDSINK | Retorno hidrônico 2
Port_1104497_1 | SOURCEANDSINK | Retorno hidrônico 2
Port_1105498_1 | SOURCEANDSINK | Retorno hidrônico 2
Port_1104516_0 | SOURCEANDSINK | Retorno hidrônico 2
Port_1104518_3 | SOURCEANDSINK | Retorno hidrônico 2
Port_1104516_1 | SOURCEANDSINK | Retorno hidrônico 2
Port_1104528_1 | SOURCEANDSINK | Retorno hidrônico 2
Port_1104518_1 | SOURCEANDSINK | Outros 5
Port_1104522_1 | SOURCEANDSINK | Outros 5
Port_1104518_2 | SOURCEANDSINK | Outros 5
Port_1104524_1 | SOURCEANDSINK | Outros 5
Port_1104519_1 | SOURCEANDSINK | Outros 5
Port_1104524_2 | SOURCEANDSINK | Outros 5
Port_1104528_2 | SOURCEANDSINK | Retorno hidrônico 2
Port_1114168_1 | SOURCEANDSINK | Retorno hidrônico 2
Port_1104532_0 | SOURCEANDSINK | Retorno hidrônico 2
Port_1105498_2 | SOURCEANDSINK | Retorno hidrônico 2
Port_1104532_1 | SOURCEANDSINK | Retorno hidrônico 2
Port_1114170_2 | SOURCEANDSINK | Retorno hidrônico 2
Port_1104560_0 | SOURCEANDSINK | Outros 4
Port_1104570_2 | SOURCEANDSINK | Outros 4
Port_1104560_1 | SOURCEANDSINK | Outros 4
Port_1104651_2 | SOURCEANDSINK | Outros 4
Port_1104639_0 | SOURCEANDSINK | Outros 4
Port_1104995_1 | SOURCEANDSINK | Outros 4
Port_1104639_1 | SOURCEANDSINK | Outros 4
Port_1104838_2 | SOURCEANDSINK | Outros 4
Port_1104651_1 | SOURCEANDSINK | Outros 4
Port_1104996_0 | SOURCEANDSINK | Outros 4
Port_1104671_0 | SOURCEANDSINK | Outros 4
Port_1104836_2 | SOURCEANDSINK | Outros 4
Port_1104671_1 | SOURCEANDSINK | Outros 4
Port_1104840_2 | SOURCEANDSINK | Outros 4
Port_1104838_1 | SOURCEANDSINK | Outros 4
Port_1104840_1 | SOURCEANDSINK | Outros 4
Port_1104855_0 | SOURCEANDSINK | Outros 6
Port_1104865_2 | SOURCEANDSINK | Outros 6
Port_1104855_1 | SOURCEANDSINK | Outros 6
Port_1104873_2 | SOURCEANDSINK | Outros 6
Port_1104867_0 | SOURCEANDSINK | Outros 6
Port_1105059_1 | SOURCEANDSINK | Outros 6
Port_1104867_1 | SOURCEANDSINK | Outros 6
Port_1104966_2 | SOURCEANDSINK | Outros 6
Port_1104873_1 | SOURCEANDSINK | Outros 6
Port_1105060_0 | SOURCEANDSINK | Outros 6
Port_1104893_0 | SOURCEANDSINK | Outros 6
Port_1104964_2 | SOURCEANDSINK | Outros 6
Port_1104893_1 | SOURCEANDSINK | Outros 6
Port_1104966_1 | SOURCEANDSINK | Outros 6
Port_1104987_0 | SOURCEANDSINK | Outros 4
Port_1114246_2 | SOURCEANDSINK | Outros 4
Port_1104987_1 | SOURCEANDSINK | Outros 4
Port_1105005_1 | SOURCEANDSINK | Outros 4
Port_1104995_2 | SOURCEANDSINK | Outros 4
Port_1104996_1 | SOURCEANDSINK | Outros 4
Port_1104995_3 | SOURCEANDSINK | Outros 4
Port_1114246_1 | SOURCEANDSINK | Outros 4
Port_1105005_2 | SOURCEANDSINK | Outros 4
Port_1105108_0 | SOURCEANDSINK | Outros 4
Port_1105051_0 | SOURCEANDSINK | Outros 6
Port_1114253_2 | SOURCEANDSINK | Outros 6
Port_1105051_1 | SOURCEANDSINK | Outros 6
Port_1105069_1 | SOURCEANDSINK | Outros 6
Port_1105059_2 | SOURCEANDSINK | Outros 6
Port_1105060_1 | SOURCEANDSINK | Outros 6
Port_1105059_3 | SOURCEANDSINK | Outros 6
Port_1114253_1 | SOURCEANDSINK | Outros 6
Port_1105069_2 | SOURCEANDSINK | Outros 6
Port_1105141_0 | SOURCEANDSINK | Outros 6
Port_1105089_0 | SOURCEANDSINK | Outros 4
Port_1105115_2 | SOURCEANDSINK | Outros 4
Port_1105089_1 | SOURCEANDSINK | Outros 4
Port_1105117_1 | SOURCEANDSINK | Outros 4
Port_1105107_1 | SOURCEANDSINK | Outros 4
Port_1114216_1 | SOURCEANDSINK | Outros 4
Port_1105107_2 | SOURCEANDSINK | Outros 4
Port_1114236_1 | SOURCEANDSINK | Outros 4
Port_1105107_3 | SOURCEANDSINK | Outros 4
Port_1105115_1 | SOURCEANDSINK | Outros 4
Port_1105108_1 | SOURCEANDSINK | Outros 4
Port_1114236_2 | SOURCEANDSINK | Outros 4
Port_1105128_0 | SOURCEANDSINK | Outros 6
Port_1105140_3 | SOURCEANDSINK | Outros 6
Port_1105128_1 | SOURCEANDSINK | Outros 6
Port_1105144_1 | SOURCEANDSINK | Outros 6
Port_1105140_1 | SOURCEANDSINK | Outros 6
Port_1114225_1 | SOURCEANDSINK | Outros 6
Port_1105140_2 | SOURCEANDSINK | Outros 6
Port_1114255_1 | SOURCEANDSINK | Outros 6
Port_1105141_1 | SOURCEANDSINK | Outros 6
Port_1114255_2 | SOURCEANDSINK | Outros 6
Port_1105172_0 | SOURCEANDSINK | Outros 4
Port_1105199_2 | SOURCEANDSINK | Outros 4
Port_1105172_1 | SOURCEANDSINK | Outros 4
Port_1105201_1 | SOURCEANDSINK | Outros 4
Port_1105191_1 | SOURCEANDSINK | Outros 4
Port_1114200_1 | SOURCEANDSINK | Outros 4
Port_1105191_2 | SOURCEANDSINK | Outros 4
Port_1114218_1 | SOURCEANDSINK | Outros 4
Port_1105191_3 | SOURCEANDSINK | Outros 4
Port_1105199_1 | SOURCEANDSINK | Outros 4
Port_1105192_0 | SOURCEANDSINK | Outros 4
Port_1114216_2 | SOURCEANDSINK | Outros 4
Port_1105192_1 | SOURCEANDSINK | Outros 4
Port_1114218_2 | SOURCEANDSINK | Outros 4
Port_1105212_0 | SOURCEANDSINK | Outros 6
Port_1105243_2 | SOURCEANDSINK | Outros 6
Port_1105212_1 | SOURCEANDSINK | Outros 6
Port_1105246_1 | SOURCEANDSINK | Outros 6
Port_1105235_1 | SOURCEANDSINK | Outros 6
Port_1114208_1 | SOURCEANDSINK | Outros 6
Port_1105235_2 | SOURCEANDSINK | Outros 6
Port_1114227_1 | SOURCEANDSINK | Outros 6
Port_1105235_3 | SOURCEANDSINK | Outros 6
Port_1105243_1 | SOURCEANDSINK | Outros 6
Port_1105236_0 | SOURCEANDSINK | Outros 6
Port_1114225_2 | SOURCEANDSINK | Outros 6
Port_1105236_1 | SOURCEANDSINK | Outros 6
Port_1114227_2 | SOURCEANDSINK | Outros 6
Port_1105318_0 | SOURCEANDSINK | Outros 4
Port_1105338_2 | SOURCEANDSINK | Outros 4
Port_1105318_1 | SOURCEANDSINK | Outros 4
Port_1105340_1 | SOURCEANDSINK | Outros 4
Port_1105330_1 | SOURCEANDSINK | Outros 4
Port_1114677_1 | SOURCEANDSINK | Outros 4
Port_1105330_2 | SOURCEANDSINK | Outros 4
Port_1114202_1 | SOURCEANDSINK | Outros 4
Port_1105330_3 | SOURCEANDSINK | Outros 4
Port_1105338_1 | SOURCEANDSINK | Outros 4
Port_1105331_0 | SOURCEANDSINK | Outros 4
Port_1114200_2 | SOURCEANDSINK | Outros 4
Port_1105331_1 | SOURCEANDSINK | Outros 4
Port_1114202_2 | SOURCEANDSINK | Outros 4
Port_1105351_0 | SOURCEANDSINK | Outros 6
Port_1105374_2 | SOURCEANDSINK | Outros 6
Port_1105351_1 | SOURCEANDSINK | Outros 6
Port_1105376_1 | SOURCEANDSINK | Outros 6
Port_1105366_1 | SOURCEANDSINK | Outros 6
Port_1114687_1 | SOURCEANDSINK | Outros 6
Port_1105366_2 | SOURCEANDSINK | Outros 6
Port_1114210_1 | SOURCEANDSINK | Outros 6
Port_1105366_3 | SOURCEANDSINK | Outros 6
Port_1105374_1 | SOURCEANDSINK | Outros 6
Port_1105367_0 | SOURCEANDSINK | Outros 6
Port_1114208_2 | SOURCEANDSINK | Outros 6
Port_1105367_1 | SOURCEANDSINK | Outros 6
Port_1114210_2 | SOURCEANDSINK | Outros 6
Port_1105482_0 | SOURCEANDSINK | Retorno hidrônico 2
Port_1105492_2 | SOURCEANDSINK | Retorno hidrônico 2
Port_1105482_1 | SOURCEANDSINK | Retorno hidrônico 2
Port_1105500_1 | SOURCEANDSINK | Retorno hidrônico 2
Port_1105484_1 | SOURCEANDSINK | Outros 4
Port_1111916_2 | SOURCEANDSINK | Outros 4
Port_1105484_2 | SOURCEANDSINK | Outros 4
Port_1114679_1 | SOURCEANDSINK | Outros 4
Port_1105484_3 | SOURCEANDSINK | Outros 4
Port_1105492_1 | SOURCEANDSINK | Outros 4
Port_1105485_0 | SOURCEANDSINK | Outros 4
Port_1114720_1 | SOURCEANDSINK | Outros 4
Port_1105485_1 | SOURCEANDSINK | Outros 4
Port_1114679_2 | SOURCEANDSINK | Outros 4
Port_1105500_2 | SOURCEANDSINK | Retorno hidrônico 2
Port_1114170_1 | SOURCEANDSINK | Retorno hidrônico 2
Port_1105517_0 | SOURCEANDSINK | Outros 6
Port_1114172_2 | SOURCEANDSINK | Outros 6
Port_1105517_1 | SOURCEANDSINK | Outros 6
Port_1105549_1 | SOURCEANDSINK | Outros 6
Port_1105525_2 | SOURCEANDSINK | Outros 6
Port_1105526_1 | SOURCEANDSINK | Outros 6
Port_1105525_3 | SOURCEANDSINK | Outros 6
Port_1114172_1 | SOURCEANDSINK | Outros 6
Port_1105529_0 | SOURCEANDSINK | Outros 6
Port_1114174_2 | SOURCEANDSINK | Outros 6
Port_1105529_1 | SOURCEANDSINK | Outros 6
Port_1105549_2 | SOURCEANDSINK | Outros 6
Port_1105539_1 | SOURCEANDSINK | Outros 6
Port_1111959_2 | SOURCEANDSINK | Outros 6
Port_1105539_2 | SOURCEANDSINK | Outros 6
Port_1114689_1 | SOURCEANDSINK | Outros 6
Port_1105539_3 | SOURCEANDSINK | Outros 6
Port_1114174_1 | SOURCEANDSINK | Outros 6
Port_1105540_0 | SOURCEANDSINK | Outros 6
Port_1114784_1 | SOURCEANDSINK | Outros 6
Port_1105540_1 | SOURCEANDSINK | Outros 6
Port_1114689_2 | SOURCEANDSINK | Outros 6
Port_1105683_0 | SOURCEANDSINK | Outros 4
Port_1105693_2 | SOURCEANDSINK | Outros 4
Port_1105683_1 | SOURCEANDSINK | Outros 4
Port_1105765_2 | SOURCEANDSINK | Outros 4
Port_1105725_0 | SOURCEANDSINK | Outros 4
Port_1105735_2 | SOURCEANDSINK | Outros 4
Port_1105725_1 | SOURCEANDSINK | Outros 4
Port_1105767_1 | SOURCEANDSINK | Outros 4
Port_1105765_1 | SOURCEANDSINK | Outros 4
Port_1106043_0 | SOURCEANDSINK | Outros 4
Port_1105767_2 | SOURCEANDSINK | Outros 4
Port_1106014_1 | SOURCEANDSINK | Outros 4
Port_1105782_0 | SOURCEANDSINK | Outros 6
Port_1105792_2 | SOURCEANDSINK | Outros 6
Port_1105782_1 | SOURCEANDSINK | Outros 6
Port_1106139_2 | SOURCEANDSINK | Outros 6
Port_1105822_0 | SOURCEANDSINK | Outros 6
Port_1105874_2 | SOURCEANDSINK | Outros 6
Port_1105822_1 | SOURCEANDSINK | Outros 6
Port_1106137_1 | SOURCEANDSINK | Outros 6
Port_1106003_0 | SOURCEANDSINK | Outros 4
Port_1114296_2 | SOURCEANDSINK | Outros 4
Port_1106003_1 | SOURCEANDSINK | Outros 4
Port_1114298_2 | SOURCEANDSINK | Outros 4
Port_1106014_0 | SOURCEANDSINK | Outros 4
Port_1106046_2 | SOURCEANDSINK | Outros 4
Port_1106032_1 | SOURCEANDSINK | Outros 4
Port_1114333_1 | SOURCEANDSINK | Outros 4
Port_1106032_2 | SOURCEANDSINK | Outros 4
Port_1114316_1 | SOURCEANDSINK | Outros 4
Port_1106032_3 | SOURCEANDSINK | Outros 4
Port_1114296_1 | SOURCEANDSINK | Outros 4
Port_1106033_0 | SOURCEANDSINK | Outros 4
Port_1114318_2 | SOURCEANDSINK | Outros 4
Port_1106033_1 | SOURCEANDSINK | Outros 4
Port_1114316_2 | SOURCEANDSINK | Outros 4
Port_1106042_1 | SOURCEANDSINK | Outros 4
Port_1106046_1 | SOURCEANDSINK | Outros 4
Port_1106042_2 | SOURCEANDSINK | Outros 4
Port_1106048_1 | SOURCEANDSINK | Outros 4
Port_1106042_3 | SOURCEANDSINK | Outros 4
Port_1114298_1 | SOURCEANDSINK | Outros 4
Port_1106043_1 | SOURCEANDSINK | Outros 4
Port_1106048_2 | SOURCEANDSINK | Outros 4
Port_1106053_0 | SOURCEANDSINK | Outros 6
Port_1114304_2 | SOURCEANDSINK | Outros 6
Port_1106053_1 | SOURCEANDSINK | Outros 6
Port_1114306_2 | SOURCEANDSINK | Outros 6
Port_1106137_2 | SOURCEANDSINK | Outros 6
Port_1106219_0 | SOURCEANDSINK | Outros 6
Port_1106139_1 | SOURCEANDSINK | Outros 6
Port_1106157_1 | SOURCEANDSINK | Outros 6
Port_1106157_0 | SOURCEANDSINK | Outros 6
Port_1106218_1 | SOURCEANDSINK | Outros 6
Port_1106218_2 | SOURCEANDSINK | Outros 6
Port_1106219_1 | SOURCEANDSINK | Outros 6
Port_1106218_3 | SOURCEANDSINK | Outros 6
Port_1114304_1 | SOURCEANDSINK | Outros 6
Port_1106222_1 | SOURCEANDSINK | Outros 6
Port_1114341_1 | SOURCEANDSINK | Outros 6
Port_1106222_2 | SOURCEANDSINK | Outros 6
Port_1114325_1 | SOURCEANDSINK | Outros 6
Port_1106222_3 | SOURCEANDSINK | Outros 6
Port_1114306_1 | SOURCEANDSINK | Outros 6
Port_1106223_0 | SOURCEANDSINK | Outros 6
Port_1114327_2 | SOURCEANDSINK | Outros 6
Port_1106223_1 | SOURCEANDSINK | Outros 6
Port_1114325_2 | SOURCEANDSINK | Outros 6
Port_1106299_0 | SOURCEANDSINK | Outros 4
Port_1106311_2 | SOURCEANDSINK | Outros 4
Port_1106299_1 | SOURCEANDSINK | Outros 4
Port_1106399_1 | SOURCEANDSINK | Outros 4
Port_1106396_0 | SOURCEANDSINK | Outros 4
Port_1106399_2 | SOURCEANDSINK | Outros 4
Port_1106396_1 | SOURCEANDSINK | Outros 4
Port_1106433_1 | SOURCEANDSINK | Outros 4
Port_1106403_0 | SOURCEANDSINK | Outros 4
Port_1106431_2 | SOURCEANDSINK | Outros 4
Port_1106403_1 | SOURCEANDSINK | Outros 4
Port_1106433_2 | SOURCEANDSINK | Outros 4
Port_1106423_1 | SOURCEANDSINK | Outros 4
Port_1114472_1 | SOURCEANDSINK | Outros 4
Port_1106423_2 | SOURCEANDSINK | Outros 4
Port_1114335_1 | SOURCEANDSINK | Outros 4
Port_1106423_3 | SOURCEANDSINK | Outros 4
Port_1106431_1 | SOURCEANDSINK | Outros 4
Port_1106424_0 | SOURCEANDSINK | Outros 4
Port_1114333_2 | SOURCEANDSINK | Outros 4
Port_1106424_1 | SOURCEANDSINK | Outros 4
Port_1114335_2 | SOURCEANDSINK | Outros 4
Port_1106460_0 | SOURCEANDSINK | Outros 6
Port_1106488_2 | SOURCEANDSINK | Outros 6
Port_1106460_1 | SOURCEANDSINK | Outros 6
Port_1106490_1 | SOURCEANDSINK | Outros 6
Port_1106480_1 | SOURCEANDSINK | Outros 6
Port_1114481_1 | SOURCEANDSINK | Outros 6
Port_1106480_2 | SOURCEANDSINK | Outros 6
Port_1114343_1 | SOURCEANDSINK | Outros 6
Port_1106480_3 | SOURCEANDSINK | Outros 6
Port_1106488_1 | SOURCEANDSINK | Outros 6
Port_1106481_0 | SOURCEANDSINK | Outros 6
Port_1114341_2 | SOURCEANDSINK | Outros 6
Port_1106481_1 | SOURCEANDSINK | Outros 6
Port_1114343_2 | SOURCEANDSINK | Outros 6
Port_1106658_0 | SOURCEANDSINK | Outros 8
Port_1106688_1 | SOURCEANDSINK | Outros 8
Port_1106658_1 | SOURCEANDSINK | Outros 8
Port_1106759_1 | SOURCEANDSINK | Outros 8
Port_1106753_0 | SOURCEANDSINK | Outros 8
Port_1107149_1 | SOURCEANDSINK | Outros 8
Port_1106753_1 | SOURCEANDSINK | Outros 8
Port_1106829_1 | SOURCEANDSINK | Outros 8
Port_1106759_2 | SOURCEANDSINK | Outros 8
Port_1107150_0 | SOURCEANDSINK | Outros 8
Port_1106779_0 | SOURCEANDSINK | Outros 8
Port_1106827_2 | SOURCEANDSINK | Outros 8
Port_1106779_1 | SOURCEANDSINK | Outros 8
Port_1106829_2 | SOURCEANDSINK | Outros 8
Port_1106848_0 | SOURCEANDSINK | Outros 6
Port_1106894_2 | SOURCEANDSINK | Outros 6
Port_1106848_1 | SOURCEANDSINK | Outros 6
Port_1106980_1 | SOURCEANDSINK | Outros 6
Port_1106951_0 | SOURCEANDSINK | Outros 6
Port_1107074_2 | SOURCEANDSINK | Outros 6
Port_1106951_1 | SOURCEANDSINK | Outros 6
Port_1107078_2 | SOURCEANDSINK | Outros 6
Port_1106980_2 | SOURCEANDSINK | Outros 6
Port_1107405_0 | SOURCEANDSINK | Outros 6
Port_1107076_1 | SOURCEANDSINK | Outros 6
Port_1107361_1 | SOURCEANDSINK | Outros 6
Port_1107076_2 | SOURCEANDSINK | Outros 6
Port_1107078_1 | SOURCEANDSINK | Outros 6
Port_1107138_0 | SOURCEANDSINK | Outros 4
Port_1114455_2 | SOURCEANDSINK | Outros 4
Port_1107138_1 | SOURCEANDSINK | Outros 4
Port_1114457_2 | SOURCEANDSINK | Outros 4
Port_1107149_2 | SOURCEANDSINK | Outros 8
Port_1107150_1 | SOURCEANDSINK | Outros 8
Port_1107149_3 | SOURCEANDSINK | Outros 8
Port_1107166_1 | SOURCEANDSINK | Outros 4
Port_1114498_1 | SOURCEANDSINK | Outros 4
Port_1107166_2 | SOURCEANDSINK | Outros 4
Port_1114474_1 | SOURCEANDSINK | Outros 4
Port_1107166_3 | SOURCEANDSINK | Outros 4
Port_1114455_1 | SOURCEANDSINK | Outros 4
Port_1107167_0 | SOURCEANDSINK | Outros 4
Port_1114472_2 | SOURCEANDSINK | Outros 4
Port_1107167_1 | SOURCEANDSINK | Outros 4
Port_1114474_2 | SOURCEANDSINK | Outros 4
OutPort_1107176_1 | SOURCE | Outros 4
Port_1107176_2 | SOURCEANDSINK | Outros 4
Port_1114457_1 | SOURCEANDSINK | Outros 4
Port_1107244_0 | SOURCEANDSINK | Outros 6
Port_1114371_2 | SOURCEANDSINK | Outros 6
Port_1107244_1 | SOURCEANDSINK | Outros 6
Port_1114373_2 | SOURCEANDSINK | Outros 6
Port_1107260_1 | SOURCEANDSINK
Port_1107260_2 | SOURCEANDSINK
Port_1107361_0 | SOURCEANDSINK | Outros 6
Port_1107404_1 | SOURCEANDSINK | Outros 6
Port_1107404_2 | SOURCEANDSINK | Outros 6
Port_1107405_1 | SOURCEANDSINK | Outros 6
Port_1107404_3 | SOURCEANDSINK | Outros 6
Port_1114371_1 | SOURCEANDSINK | Outros 6
Port_1107414_1 | SOURCEANDSINK | Outros 6
Port_1114489_1 | SOURCEANDSINK | Outros 6
Port_1107414_2 | SOURCEANDSINK | Outros 6
Port_1114483_1 | SOURCEANDSINK | Outros 6
Port_1107414_3 | SOURCEANDSINK | Outros 6
Port_1114373_1 | SOURCEANDSINK | Outros 6
Port_1107415_0 | SOURCEANDSINK | Outros 6
Port_1114481_2 | SOURCEANDSINK | Outros 6
Port_1107415_1 | SOURCEANDSINK | Outros 6
Port_1114483_2 | SOURCEANDSINK | Outros 6
Port_1107456_0 | SOURCEANDSINK | Outros 4
Port_1107470_2 | SOURCEANDSINK | Outros 4
Port_1107456_1 | SOURCEANDSINK | Outros 4
Port_1107480_2 | SOURCEANDSINK | Outros 4
Port_1107472_0 | SOURCEANDSINK | Outros 4
Port_1108132_2 | SOURCEANDSINK | Outros 4
Port_1107472_1 | SOURCEANDSINK | Outros 4
Port_1107574_2 | SOURCEANDSINK | Outros 4
Port_1107480_1 | SOURCEANDSINK | Outros 4
Port_1108129_0 | SOURCEANDSINK | Outros 4
Port_1107500_0 | SOURCEANDSINK | Outros 4
Port_1107572_2 | SOURCEANDSINK | Outros 4
Port_1107500_1 | SOURCEANDSINK | Outros 4
Port_1107574_1 | SOURCEANDSINK | Outros 4
Port_1107589_0 | SOURCEANDSINK | Outros 6
Port_1107601_2 | SOURCEANDSINK | Outros 6
Port_1107589_1 | SOURCEANDSINK | Outros 6
Port_1107673_1 | SOURCEANDSINK | Outros 6
Port_1107603_0 | SOURCEANDSINK | Outros 6
Port_1108182_1 | SOURCEANDSINK | Outros 6
Port_1107603_1 | SOURCEANDSINK | Outros 6
Port_1107677_1 | SOURCEANDSINK | Outros 6
Port_1107635_0 | SOURCEANDSINK | Outros 6
Port_1107647_2 | SOURCEANDSINK | Outros 6
Port_1107635_1 | SOURCEANDSINK | Outros 6
Port_1107677_2 | SOURCEANDSINK | Outros 6
Port_1107673_2 | SOURCEANDSINK | Outros 6
Port_1108183_0 | SOURCEANDSINK | Outros 6
Port_1107694_0 | SOURCEANDSINK | Outros 4
Port_1107708_2 | SOURCEANDSINK | Outros 4
Port_1107694_1 | SOURCEANDSINK | Outros 4
Port_1107718_1 | SOURCEANDSINK | Outros 4
Port_1107710_0 | SOURCEANDSINK | Outros 4
Port_1108293_2 | SOURCEANDSINK | Outros 4
Port_1107710_1 | SOURCEANDSINK | Outros 4
Port_1107850_1 | SOURCEANDSINK | Outros 4
Port_1107718_2 | SOURCEANDSINK | Outros 4
Port_1108290_0 | SOURCEANDSINK | Outros 4
Port_1107738_0 | SOURCEANDSINK | Outros 4
Port_1107848_2 | SOURCEANDSINK | Outros 4
Port_1107738_1 | SOURCEANDSINK | Outros 4
Port_1107850_2 | SOURCEANDSINK | Outros 4
Port_1107865_0 | SOURCEANDSINK | Outros 6
Port_1107875_2 | SOURCEANDSINK | Outros 6
Port_1107865_1 | SOURCEANDSINK | Outros 6
Port_1107885_2 | SOURCEANDSINK | Outros 6
Port_1107877_0 | SOURCEANDSINK | Outros 6
Port_1108258_1 | SOURCEANDSINK | Outros 6
Port_1107877_1 | SOURCEANDSINK | Outros 6
Port_1107994_2 | SOURCEANDSINK | Outros 6
Port_1107885_1 | SOURCEANDSINK | Outros 6
Port_1108259_0 | SOURCEANDSINK | Outros 6
Port_1107905_0 | SOURCEANDSINK | Outros 6
Port_1107992_2 | SOURCEANDSINK | Outros 6
Port_1107905_1 | SOURCEANDSINK | Outros 6
Port_1107994_1 | SOURCEANDSINK | Outros 6
Port_1108003_0 | SOURCEANDSINK | Outros 4
Port_1114554_2 | SOURCEANDSINK | Outros 4
Port_1108003_1 | SOURCEANDSINK | Outros 4
Port_1108279_1 | SOURCEANDSINK | Outros 4
Port_1108065_0 | SOURCEANDSINK | Outros 6
Port_1108198_1 | SOURCEANDSINK | Outros 6
Port_1108065_1 | SOURCEANDSINK | Outros 6
Port_1108248_1 | SOURCEANDSINK | Outros 6
Port_1108118_0 | SOURCEANDSINK | Outros 4
Port_1114534_2 | SOURCEANDSINK | Outros 4
Port_1108118_1 | SOURCEANDSINK | Outros 4
Port_1108161_2 | SOURCEANDSINK | Outros 4
Port_1108128_1 | SOURCEANDSINK | Outros 4
Port_1108132_1 | SOURCEANDSINK | Outros 4
Port_1108128_2 | SOURCEANDSINK | Outros 4
Port_1108134_1 | SOURCEANDSINK | Outros 4
Port_1108128_3 | SOURCEANDSINK | Outros 4
Port_1114534_1 | SOURCEANDSINK | Outros 4
Port_1108129_1 | SOURCEANDSINK | Outros 4
Port_1108134_2 | SOURCEANDSINK | Outros 4
Port_1108138_0 | SOURCEANDSINK | Outros 4
Port_1114529_2 | SOURCEANDSINK | Outros 4
Port_1108138_1 | SOURCEANDSINK | Outros 4
Port_1108161_1 | SOURCEANDSINK | Outros 4
Port_1108151_1 | SOURCEANDSINK | Outros 4
Port_1114554_1 | SOURCEANDSINK | Outros 4
Port_1108151_2 | SOURCEANDSINK | Outros 4
Port_1114517_1 | SOURCEANDSINK | Outros 4
Port_1108151_3 | SOURCEANDSINK | Outros 4
Port_1114529_1 | SOURCEANDSINK | Outros 4
Port_1108152_0 | SOURCEANDSINK | Outros 4
Port_1114517_2 | SOURCEANDSINK | Outros 4
Port_1108152_1 | SOURCEANDSINK | Outros 4
Port_1109925_1 | SOURCEANDSINK | Outros 4
Port_1108176_0 | SOURCEANDSINK | Outros 6
Port_1108182_3 | SOURCEANDSINK | Outros 6
Port_1108176_1 | SOURCEANDSINK | Outros 6
Port_1108208_2 | SOURCEANDSINK | Outros 6
Port_1108182_2 | SOURCEANDSINK | Outros 6
Port_1108183_1 | SOURCEANDSINK | Outros 6
Port_1108186_0 | SOURCEANDSINK | Outros 6
Port_1108198_3 | SOURCEANDSINK | Outros 6
Port_1108186_1 | SOURCEANDSINK | Outros 6
Port_1114544_2 | SOURCEANDSINK | Outros 6
Port_1108198_2 | SOURCEANDSINK | Outros 6
Port_1114523_1 | SOURCEANDSINK | Outros 6
Port_1108199_0 | SOURCEANDSINK | Outros 6
Port_1114523_2 | SOURCEANDSINK | Outros 6
Port_1108199_1 | SOURCEANDSINK | Outros 6
Port_1110002_1 | SOURCEANDSINK | Outros 6
Port_1108208_1 | SOURCEANDSINK | Outros 6
Port_1114544_1 | SOURCEANDSINK | Outros 6
Port_1108240_0 | SOURCEANDSINK | Outros 6
Port_1108248_2 | SOURCEANDSINK | Outros 6
Port_1108240_1 | SOURCEANDSINK | Outros 6
Port_1108262_2 | SOURCEANDSINK | Outros 6
Port_1108250_0 | SOURCEANDSINK | Outros 6
Port_1114548_2 | SOURCEANDSINK | Outros 6
Port_1108250_1 | SOURCEANDSINK | Outros 6
Port_1108262_1 | SOURCEANDSINK | Outros 6
Port_1108258_2 | SOURCEANDSINK | Outros 6
Port_1108259_1 | SOURCEANDSINK | Outros 6
Port_1108258_3 | SOURCEANDSINK | Outros 6
Port_1114548_1 | SOURCEANDSINK | Outros 6
Port_1108271_0 | SOURCEANDSINK | Outros 4
Port_1108279_2 | SOURCEANDSINK | Outros 4
Port_1108271_1 | SOURCEANDSINK | Outros 4
Port_1108299_2 | SOURCEANDSINK | Outros 4
Port_1108281_0 | SOURCEANDSINK | Outros 4
Port_1114556_2 | SOURCEANDSINK | Outros 4
Port_1108281_1 | SOURCEANDSINK | Outros 4
Port_1108299_1 | SOURCEANDSINK | Outros 4
Port_1108289_1 | SOURCEANDSINK | Outros 4
Port_1108293_1 | SOURCEANDSINK | Outros 4
Port_1108289_2 | SOURCEANDSINK | Outros 4
Port_1108295_1 | SOURCEANDSINK | Outros 4
Port_1108289_3 | SOURCEANDSINK | Outros 4
Port_1114556_1 | SOURCEANDSINK | Outros 4
Port_1108290_1 | SOURCEANDSINK | Outros 4
Port_1108295_2 | SOURCEANDSINK | Outros 4
Port_1108380_0 | SOURCEANDSINK | Outros 4
Port_1108598_2 | SOURCEANDSINK | Outros 4
Port_1108380_1 | SOURCEANDSINK | Outros 4
Port_1108600_2 | SOURCEANDSINK | Outros 4
Port_1108430_0 | SOURCEANDSINK | Outros 4
Port_1108767_1 | SOURCEANDSINK | Outros 4
Port_1108430_1 | SOURCEANDSINK | Outros 4
Port_1108600_1 | SOURCEANDSINK | Outros 4
Port_1108442_2 | SOURCEANDSINK | Outros 4
Port_1108768_0 | SOURCEANDSINK | Outros 4
Port_1108615_0 | SOURCEANDSINK | Outros 6
Port_1108666_2 | SOURCEANDSINK | Outros 6
Port_1108615_1 | SOURCEANDSINK | Outros 6
Port_1108684_2 | SOURCEANDSINK | Outros 6
Port_1108682_2 | SOURCEANDSINK | Outros 6
Port_1108933_0 | SOURCEANDSINK | Outros 6
Port_1108684_1 | SOURCEANDSINK | Outros 6
Port_1108888_1 | SOURCEANDSINK | Outros 6
Port_1108754_0 | SOURCEANDSINK | Outros 4
Port_1114578_2 | SOURCEANDSINK | Outros 4
Port_1108754_1 | SOURCEANDSINK | Outros 4
Port_1114580_2 | SOURCEANDSINK | Outros 4
Port_1108765_0 | SOURCEANDSINK | Outros 4
Port_1108767_3 | SOURCEANDSINK | Outros 4
Port_1108765_1 | SOURCEANDSINK | Outros 4
Port_1108785_1 | SOURCEANDSINK | Outros 4
Port_1108767_2 | SOURCEANDSINK | Outros 4
Port_1108768_1 | SOURCEANDSINK | Outros 4
Port_1108775_1 | SOURCEANDSINK | Outros 4
Port_1115066_0 | SOURCEANDSINK | Outros 4
Port_1108775_2 | SOURCEANDSINK | Outros 4
Port_1108776_1 | SOURCEANDSINK | Outros 4
Port_1108775_3 | SOURCEANDSINK | Outros 4
Port_1114578_1 | SOURCEANDSINK | Outros 4
Port_1108776_0 | SOURCEANDSINK | Outros 4
Port_1114572_2 | SOURCEANDSINK | Outros 4
Port_1108785_2 | SOURCEANDSINK | Outros 4
Port_1114580_1 | SOURCEANDSINK | Outros 4
Port_1108837_0 | SOURCEANDSINK | Outros 6
Port_1114586_2 | SOURCEANDSINK | Outros 6
Port_1108837_1 | SOURCEANDSINK | Outros 6
Port_1114588_2 | SOURCEANDSINK | Outros 6
Port_1108888_0 | SOURCEANDSINK | Outros 6
Port_1108932_1 | SOURCEANDSINK | Outros 6
Port_1108923_0 | SOURCEANDSINK | Outros 6
Port_1108936_1 | SOURCEANDSINK | Outros 6
Port_1108923_1 | SOURCEANDSINK | Outros 6
Port_1109178_1 | SOURCEANDSINK | Outros 6
Port_1108932_2 | SOURCEANDSINK | Outros 6
Port_1108933_1 | SOURCEANDSINK | Outros 6
Port_1108932_3 | SOURCEANDSINK | Outros 6
Port_1114586_1 | SOURCEANDSINK | Outros 6
Port_1108936_2 | SOURCEANDSINK | Outros 6
Port_1108937_1 | SOURCEANDSINK | Outros 6
Port_1108936_3 | SOURCEANDSINK | Outros 6
Port_1114588_1 | SOURCEANDSINK | Outros 6
Port_1108937_0 | SOURCEANDSINK | Outros 6
Port_1114566_2 | SOURCEANDSINK | Outros 6
Port_1109175_0 | SOURCEANDSINK | Outros 6
Port_1109178_2 | SOURCEANDSINK | Outros 6
Port_1109175_1 | SOURCEANDSINK | Outros 6
Port_1109188_1 | SOURCEANDSINK | Outros 6
Port_1109182_0 | SOURCEANDSINK | Outros 6
Port_1109188_2 | SOURCEANDSINK | Outros 6
Port_1109182_1 | SOURCEANDSINK | Outros 6
Port_1109235_1 | SOURCEANDSINK | Outros 6
Port_1109235_2 | SOURCEANDSINK | Outros 6
Port_1114974_0 | SOURCEANDSINK | Outros 6
Port_1109917_0 | SOURCEANDSINK | Outros 4
Port_1109925_2 | SOURCEANDSINK | Outros 4
Port_1109917_1 | SOURCEANDSINK | Outros 4
Port_1109933_2 | SOURCEANDSINK | Outros 4
Port_1109927_0 | SOURCEANDSINK | Outros 4
Port_1109933_1 | SOURCEANDSINK | Outros 4
Port_1109927_1 | SOURCEANDSINK | Outros 4
Port_1109949_1 | SOURCEANDSINK | Outros 4
Port_1109935_0 | SOURCEANDSINK | Outros 4
Port_1114509_2 | SOURCEANDSINK | Outros 4
Port_1109935_1 | SOURCEANDSINK | Outros 4
Port_1109949_2 | SOURCEANDSINK | Outros 4
Port_1109945_1 | SOURCEANDSINK | Outros 4
Port_1114572_1 | SOURCEANDSINK | Outros 4
Port_1109945_2 | SOURCEANDSINK | Outros 4
Port_1114500_1 | SOURCEANDSINK | Outros 4
Port_1109945_3 | SOURCEANDSINK | Outros 4
Port_1114509_1 | SOURCEANDSINK | Outros 4
Port_1109946_0 | SOURCEANDSINK | Outros 4
Port_1114498_2 | SOURCEANDSINK | Outros 4
Port_1109946_1 | SOURCEANDSINK | Outros 4
Port_1114500_2 | SOURCEANDSINK | Outros 4
Port_1109994_0 | SOURCEANDSINK | Outros 6
Port_1110002_2 | SOURCEANDSINK | Outros 6
Port_1109994_1 | SOURCEANDSINK | Outros 6
Port_1110010_2 | SOURCEANDSINK | Outros 6
Port_1110004_0 | SOURCEANDSINK | Outros 6
Port_1110010_1 | SOURCEANDSINK | Outros 6
Port_1110004_1 | SOURCEANDSINK | Outros 6
Port_1110032_1 | SOURCEANDSINK | Outros 6
Port_1110012_0 | SOURCEANDSINK | Outros 6
Port_1110022_3 | SOURCEANDSINK | Outros 6
Port_1110012_1 | SOURCEANDSINK | Outros 6
Port_1110032_2 | SOURCEANDSINK | Outros 6
Port_1110022_1 | SOURCEANDSINK | Outros 6
Port_1114566_1 | SOURCEANDSINK | Outros 6
Port_1110022_2 | SOURCEANDSINK | Outros 6
Port_1114491_1 | SOURCEANDSINK | Outros 6
Port_1110023_0 | SOURCEANDSINK | Outros 6
Port_1114489_2 | SOURCEANDSINK | Outros 6
Port_1110023_1 | SOURCEANDSINK | Outros 6
Port_1114491_2 | SOURCEANDSINK | Outros 6
Port_1110150_0 | SOURCEANDSINK | Outros 4
Port_1110166_2 | SOURCEANDSINK | Outros 4
Port_1110150_1 | SOURCEANDSINK | Outros 4
Port_1110395_2 | SOURCEANDSINK | Outros 4
Port_1110196_0 | SOURCEANDSINK | Outros 4
Port_1110210_2 | SOURCEANDSINK | Outros 4
Port_1110196_1 | SOURCEANDSINK | Outros 4
Port_1110397_1 | SOURCEANDSINK | Outros 4
Port_1110267_0 | SOURCEANDSINK | Outros 6
Port_1110277_2 | SOURCEANDSINK | Outros 6
Port_1110267_1 | SOURCEANDSINK | Outros 6
Port_1110788_1 | SOURCEANDSINK | Outros 6
Port_1110307_0 | SOURCEANDSINK | Outros 6
Port_1110317_2 | SOURCEANDSINK | Outros 6
Port_1110307_1 | SOURCEANDSINK | Outros 6
Port_1110786_2 | SOURCEANDSINK | Outros 6
Port_1110332_0 | SOURCEANDSINK | Outros 4
Port_1114627_2 | SOURCEANDSINK | Outros 4
Port_1110332_1 | SOURCEANDSINK | Outros 4
Port_1110560_1 | SOURCEANDSINK | Outros 4
Port_1110348_0 | SOURCEANDSINK | Outros 4
Port_1110418_2 | SOURCEANDSINK | Outros 4
Port_1110348_1 | SOURCEANDSINK | Outros 4
Port_1110397_2 | SOURCEANDSINK | Outros 4
Port_1110395_1 | SOURCEANDSINK | Outros 4
Port_1110415_0 | SOURCEANDSINK | Outros 4
Port_1110414_1 | SOURCEANDSINK | Outros 4
Port_1110418_1 | SOURCEANDSINK | Outros 4
Port_1110414_2 | SOURCEANDSINK | Outros 4
Port_1110420_1 | SOURCEANDSINK | Outros 4
Port_1110414_3 | SOURCEANDSINK | Outros 4
Port_1114627_1 | SOURCEANDSINK | Outros 4
Port_1110415_1 | SOURCEANDSINK | Outros 4
Port_1110420_2 | SOURCEANDSINK | Outros 4
Port_1110429_0 | SOURCEANDSINK | Outros 4
Port_1110560_2 | SOURCEANDSINK | Outros 4
Port_1110429_1 | SOURCEANDSINK | Outros 4
Port_1110562_3 | SOURCEANDSINK | Outros 4
Port_1110526_0 | SOURCEANDSINK | Outros 4
Port_1110534_2 | SOURCEANDSINK | Outros 4
Port_1110526_1 | SOURCEANDSINK | Outros 4
Port_1111180_1 | SOURCEANDSINK | Outros 4
Port_1110534_1 | SOURCEANDSINK | Outros 4
Port_1110563_0 | SOURCEANDSINK | Outros 4
Port_1110555_0 | SOURCEANDSINK | Outros 4
Port_1111003_2 | SOURCEANDSINK | Outros 4
Port_1110555_1 | SOURCEANDSINK | Outros 4
Port_1111005_1 | SOURCEANDSINK | Outros 4
Port_1110562_1 | SOURCEANDSINK | Outros 4
Port_1111003_1 | SOURCEANDSINK | Outros 4
Port_1110562_2 | SOURCEANDSINK | Outros 4
Port_1110563_1 | SOURCEANDSINK | Outros 4
Port_1110664_0 | SOURCEANDSINK | Outros 6
Port_1111299_2 | SOURCEANDSINK | Outros 6
Port_1110664_1 | SOURCEANDSINK | Outros 6
Port_1114631_2 | SOURCEANDSINK | Outros 6
Port_1110708_0 | SOURCEANDSINK | Outros 6
Port_1111299_1 | SOURCEANDSINK | Outros 6
Port_1110708_1 | SOURCEANDSINK | Outros 6
Port_1114629_2 | SOURCEANDSINK | Outros 6
Port_1110732_0 | SOURCEANDSINK | Outros 6
Port_1111290_1 | SOURCEANDSINK | Outros 6
Port_1110732_1 | SOURCEANDSINK | Outros 6
Port_1111268_1 | SOURCEANDSINK | Outros 6
Port_1110786_1 | SOURCEANDSINK | Outros 6
Port_1110830_0 | SOURCEANDSINK | Outros 6
Port_1110788_2 | SOURCEANDSINK | Outros 6
Port_1110824_1 | SOURCEANDSINK | Outros 6
Port_1110824_0 | SOURCEANDSINK | Outros 6
Port_1110829_1 | SOURCEANDSINK | Outros 6
Port_1110829_2 | SOURCEANDSINK | Outros 6
Port_1110830_1 | SOURCEANDSINK | Outros 6
Port_1110829_3 | SOURCEANDSINK | Outros 6
Port_1114629_1 | SOURCEANDSINK | Outros 6
Port_1110896_0 | SOURCEANDSINK | Outros 6
Port_1111268_2 | SOURCEANDSINK | Outros 6
Port_1110896_1 | SOURCEANDSINK | Outros 6
Port_1111358_1 | SOURCEANDSINK | Outros 6
Port_1110922_0 | SOURCEANDSINK | Outros 4
Port_1110988_2 | SOURCEANDSINK | Outros 4
Port_1110922_1 | SOURCEANDSINK | Outros 4
Port_1111005_2 | SOURCEANDSINK | Outros 4
Port_1111020_0 | SOURCEANDSINK | Outros 6
Port_1111053_2 | SOURCEANDSINK | Outros 6
Port_1111020_1 | SOURCEANDSINK | Outros 6
Port_1111266_2 | SOURCEANDSINK | Outros 6
Port_1111174_0 | SOURCEANDSINK | Outros 4
Port_1111180_2 | SOURCEANDSINK | Outros 4
Port_1111174_1 | SOURCEANDSINK | Outros 4
Port_1111211_2 | SOURCEANDSINK | Outros 4
Port_1111182_0 | SOURCEANDSINK | Outros 4
Port_1111209_2 | SOURCEANDSINK | Outros 4
Port_1111182_1 | SOURCEANDSINK | Outros 4
Port_1111211_1 | SOURCEANDSINK | Outros 4
Port_1111201_1 | SOURCEANDSINK | Outros 4
Port_1114318_1 | SOURCEANDSINK | Outros 4
Port_1111201_2 | SOURCEANDSINK | Outros 4
Port_1114287_1 | SOURCEANDSINK | Outros 4
Port_1111201_3 | SOURCEANDSINK | Outros 4
Port_1111209_1 | SOURCEANDSINK | Outros 4
Port_1111202_0 | SOURCEANDSINK | Outros 4
Port_1114287_2 | SOURCEANDSINK | Outros 4
Port_1111202_1 | SOURCEANDSINK | Outros 4
Port_1111802_1 | SOURCEANDSINK | Outros 4
Port_1111266_1 | SOURCEANDSINK | Outros 6
Port_1111291_0 | SOURCEANDSINK | Outros 6
Port_1111288_0 | SOURCEANDSINK | Outros 6
Port_1111290_3 | SOURCEANDSINK | Outros 6
Port_1111288_1 | SOURCEANDSINK | Outros 6
Port_1111301_1 | SOURCEANDSINK | Outros 6
Port_1111290_2 | SOURCEANDSINK | Outros 6
Port_1111291_1 | SOURCEANDSINK | Outros 6
Port_1111301_2 | SOURCEANDSINK | Outros 6
Port_1114631_1 | SOURCEANDSINK | Outros 6
Port_1111348_0 | SOURCEANDSINK | Outros 6
Port_1111358_2 | SOURCEANDSINK | Outros 6
Port_1111348_1 | SOURCEANDSINK | Outros 6
Port_1111368_2 | SOURCEANDSINK | Outros 6
Port_1111360_0 | SOURCEANDSINK | Outros 6
Port_1111368_1 | SOURCEANDSINK | Outros 6
Port_1111360_1 | SOURCEANDSINK | Outros 6
Port_1111376_1 | SOURCEANDSINK | Outros 6
Port_1111370_0 | SOURCEANDSINK | Outros 6
Port_1111376_2 | SOURCEANDSINK | Outros 6
Port_1111370_1 | SOURCEANDSINK | Outros 6
Port_1111411_2 | SOURCEANDSINK | Outros 6
Port_1111378_0 | SOURCEANDSINK | Outros 6
Port_1111407_2 | SOURCEANDSINK | Outros 6
Port_1111378_1 | SOURCEANDSINK | Outros 6
Port_1111411_1 | SOURCEANDSINK | Outros 6
Port_1111394_0 | SOURCEANDSINK | Outros 6
Port_1111398_3 | SOURCEANDSINK | Outros 6
Port_1111394_1 | SOURCEANDSINK | Outros 6
Port_1111405_1 | SOURCEANDSINK | Outros 6
Port_1111395_0 | SOURCEANDSINK | Outros 6
Port_1111402_2 | SOURCEANDSINK | Outros 6
Port_1111395_1 | SOURCEANDSINK | Outros 6
Port_1111407_1 | SOURCEANDSINK | Outros 6
Port_1111398_1 | SOURCEANDSINK | Outros 6
Port_1114327_1 | SOURCEANDSINK | Outros 6
Port_1111398_2 | SOURCEANDSINK | Outros 6
Port_1114290_1 | SOURCEANDSINK | Outros 6
Port_1111399_0 | SOURCEANDSINK | Outros 6
Port_1114290_2 | SOURCEANDSINK | Outros 6
Port_1111399_1 | SOURCEANDSINK | Outros 6
Port_1111844_1 | SOURCEANDSINK | Outros 6
Port_1111402_1 | SOURCEANDSINK | Outros 6
Port_1111405_2 | SOURCEANDSINK | Outros 6
Port_1111463_0 | SOURCEANDSINK | Outros 4
Port_1111802_2 | SOURCEANDSINK | Outros 4
Port_1111463_1 | SOURCEANDSINK | Outros 4
Port_1114275_2 | SOURCEANDSINK | Outros 4
Port_1111510_0 | SOURCEANDSINK | Outros 6
Port_1111844_2 | SOURCEANDSINK | Outros 6
Port_1111510_1 | SOURCEANDSINK | Outros 6
Port_1114284_2 | SOURCEANDSINK | Outros 6
Port_1111793_0 | SOURCEANDSINK | Outros 4
Port_1111914_2 | SOURCEANDSINK | Outros 4
Port_1111793_1 | SOURCEANDSINK | Outros 4
Port_1111916_1 | SOURCEANDSINK | Outros 4
Port_1111804_1 | SOURCEANDSINK | Outros 4
Port_1111914_1 | SOURCEANDSINK | Outros 4
Port_1111804_2 | SOURCEANDSINK | Outros 4
Port_1111805_1 | SOURCEANDSINK | Outros 4
Port_1111804_3 | SOURCEANDSINK | Outros 4
Port_1114275_1 | SOURCEANDSINK | Outros 4
Port_1111834_0 | SOURCEANDSINK | Retorno hidrônico 1
Port_1111957_2 | SOURCEANDSINK | Retorno hidrônico 1
Port_1111834_1 | SOURCEANDSINK | Outros 6
Port_1111959_1 | SOURCEANDSINK | Outros 6
Port_1111846_1 | SOURCEANDSINK | Retorno hidrônico 1
Port_1111957_1 | SOURCEANDSINK | Retorno hidrônico 1
Port_1111846_2 | SOURCEANDSINK | Retorno hidrônico 1
Port_1111847_1 | SOURCEANDSINK | Retorno hidrônico 1
Port_1111846_3 | SOURCEANDSINK | Retorno hidrônico 1
Port_1114284_1 | SOURCEANDSINK | Retorno hidrônico 1
Port_1112905_0 | SOURCEANDSINK | Outros 4
Port_1112921_2 | SOURCEANDSINK | Outros 4
Port_1112905_1 | SOURCEANDSINK | Outros 4
Port_1112933_1 | SOURCEANDSINK | Outros 4
Port_1112923_0 | SOURCEANDSINK | Outros 4
Port_1113099_2 | SOURCEANDSINK | Outros 4
Port_1112923_1 | SOURCEANDSINK | Outros 4
Port_1112966_1 | SOURCEANDSINK | Outros 4
Port_1112933_2 | SOURCEANDSINK | Outros 4
Port_1113096_0 | SOURCEANDSINK | Outros 4
Port_1112954_0 | SOURCEANDSINK | Outros 4
Port_1112966_2 | SOURCEANDSINK | Outros 4
Port_1112954_1 | SOURCEANDSINK | Outros 4
Port_1112968_1 | SOURCEANDSINK | Outros 4
Port_1112979_0 | SOURCEANDSINK | Outros 6
Port_1112989_2 | SOURCEANDSINK | Outros 6
Port_1112979_1 | SOURCEANDSINK | Outros 6
Port_1113055_1 | SOURCEANDSINK | Outros 6
Port_1112991_0 | SOURCEANDSINK | Outros 6
Port_1113868_1 | SOURCEANDSINK | Outros 6
Port_1112991_1 | SOURCEANDSINK | Outros 6
Port_1113059_2 | SOURCEANDSINK | Outros 6
Port_1113019_0 | SOURCEANDSINK | Outros 6
Port_1113029_2 | SOURCEANDSINK | Outros 6
Port_1113019_1 | SOURCEANDSINK | Outros 6
Port_1113057_2 | SOURCEANDSINK | Outros 6
Port_1113055_2 | SOURCEANDSINK | Outros 6
Port_1113869_0 | SOURCEANDSINK | Outros 6
Port_1113057_1 | SOURCEANDSINK | Outros 6
Port_1113059_1 | SOURCEANDSINK | Outros 6
Port_1113082_0 | SOURCEANDSINK | Outros 4
Port_1113095_3 | SOURCEANDSINK | Outros 4
Port_1113082_1 | SOURCEANDSINK | Outros 4
Port_1115063_1 | SOURCEANDSINK | Outros 4
Port_1113095_1 | SOURCEANDSINK | Outros 4
Port_1113099_1 | SOURCEANDSINK | Outros 4
Port_1113095_2 | SOURCEANDSINK | Outros 4
Port_1113101_1 | SOURCEANDSINK | Outros 4
Port_1113096_1 | SOURCEANDSINK | Outros 4
Port_1113101_2 | SOURCEANDSINK | Outros 4
Port_1113241_0 | SOURCEANDSINK | Outros 4
Port_1115195_1 | SOURCEANDSINK | Outros 4
Port_1113241_1 | SOURCEANDSINK | Outros 4
Port_1113273_1 | SOURCEANDSINK | Outros 4
Port_1113263_0 | SOURCEANDSINK | Outros 4
Port_1113273_2 | SOURCEANDSINK | Outros 4
Port_1113263_1 | SOURCEANDSINK | Outros 4
Port_1115179_2 | SOURCEANDSINK | Outros 4
Port_1113313_0 | SOURCEANDSINK | Outros 4
Port_1115063_2 | SOURCEANDSINK | Outros 4
Port_1113313_1 | SOURCEANDSINK | Outros 4
Port_1115073_2 | SOURCEANDSINK | Outros 4
Port_1113407_0 | SOURCEANDSINK | Outros 4
Port_1113669_2 | SOURCEANDSINK | Outros 4
Port_1113407_1 | SOURCEANDSINK | Outros 4
Port_1113507_2 | SOURCEANDSINK | Outros 4
Port_1113417_2 | SOURCEANDSINK | Outros 4
Port_1114757_0 | SOURCEANDSINK | Outros 4
Port_1113451_0 | SOURCEANDSINK | Outros 4
Port_1113505_2 | SOURCEANDSINK | Outros 4
Port_1113451_1 | SOURCEANDSINK | Outros 4
Port_1113507_1 | SOURCEANDSINK | Outros 4
Port_1113522_0 | SOURCEANDSINK | Outros 6
Port_1113985_1 | SOURCEANDSINK | Outros 6
Port_1113522_1 | SOURCEANDSINK | Outros 6
Port_1113608_2 | SOURCEANDSINK | Outros 6
Port_1113550_0 | SOURCEANDSINK | Outros 6
Port_1113606_2 | SOURCEANDSINK | Outros 6
Port_1113550_1 | SOURCEANDSINK | Outros 6
Port_1113610_2 | SOURCEANDSINK | Outros 6
Port_1113588_2 | SOURCEANDSINK | Outros 6
Port_1114824_0 | SOURCEANDSINK | Outros 6
Port_1113608_1 | SOURCEANDSINK | Outros 6
Port_1113610_1 | SOURCEANDSINK | Outros 6
Port_1113665_1 | SOURCEANDSINK | Outros 4
Port_1113669_1 | SOURCEANDSINK | Outros 4
Port_1113665_2 | SOURCEANDSINK | Outros 4
Port_1113671_1 | SOURCEANDSINK | Outros 4
Port_1113665_3 | SOURCEANDSINK | Outros 4
Port_1113666_0 | SOURCEANDSINK | Outros 4
Port_1114760_2 | SOURCEANDSINK | Outros 4
Port_1113666_1 | SOURCEANDSINK | Outros 4
Port_1113671_2 | SOURCEANDSINK | Outros 4
Port_1113862_0 | SOURCEANDSINK | Outros 6
Port_1113876_2 | SOURCEANDSINK | Outros 6
Port_1113862_1 | SOURCEANDSINK | Outros 6
Port_1115002_1 | SOURCEANDSINK | Outros 6
Port_1113868_2 | SOURCEANDSINK | Outros 6
Port_1113869_1 | SOURCEANDSINK | Outros 6
Port_1113868_3 | SOURCEANDSINK | Outros 6
Port_1113876_1 | SOURCEANDSINK | Outros 6
Port_1113928_0 | SOURCEANDSINK | Outros 6
Port_1114973_1 | SOURCEANDSINK | Outros 6
Port_1113928_1 | SOURCEANDSINK | Outros 6
Port_1113933_0 | SOURCEANDSINK | Outros 6
Port_1115002_2 | SOURCEANDSINK | Outros 6
Port_1113933_1 | SOURCEANDSINK | Outros 6
Port_1115012_2 | SOURCEANDSINK | Outros 6
Port_1113985_2 | SOURCEANDSINK | Outros 6
Port_1113986_1 | SOURCEANDSINK | Outros 6
Port_1113985_3 | SOURCEANDSINK | Outros 6
Port_1113993_1 | SOURCEANDSINK | Outros 6
Port_1113986_0 | SOURCEANDSINK | Outros 6
Port_1114823_1 | SOURCEANDSINK | Outros 6
Port_1113993_2 | SOURCEANDSINK | Outros 6
Port_1114077_0 | SOURCEANDSINK | Outros 6
Port_1114089_2 | SOURCEANDSINK | Outros 6
Port_1114077_1 | SOURCEANDSINK | Outros 6
Port_1114101_1 | SOURCEANDSINK | Outros 6
Port_1114091_0 | SOURCEANDSINK | Outros 6
Port_1114101_2 | SOURCEANDSINK | Outros 6
Port_1114091_1 | SOURCEANDSINK | Outros 6
Port_1115123_2 | SOURCEANDSINK | Outros 6
Port_1114677_2 | SOURCEANDSINK | Outros 4
Port_1114721_0 | SOURCEANDSINK | Outros 4
Port_1114687_2 | SOURCEANDSINK | Outros 6
Port_1114785_0 | SOURCEANDSINK | Outros 6
Port_1114710_0 | SOURCEANDSINK | Outros 4
Port_1114728_2 | SOURCEANDSINK | Outros 4
Port_1114710_1 | SOURCEANDSINK | Outros 4
Port_1114736_1 | SOURCEANDSINK | Outros 4
Port_1114720_2 | SOURCEANDSINK | Outros 4
Port_1114721_1 | SOURCEANDSINK | Outros 4
Port_1114720_3 | SOURCEANDSINK | Outros 4
Port_1114728_1 | SOURCEANDSINK | Outros 4
Port_1114730_0 | SOURCEANDSINK | Outros 4
Port_1114736_2 | SOURCEANDSINK | Outros 4
Port_1114730_1 | SOURCEANDSINK | Outros 4
Port_1114746_1 | SOURCEANDSINK | Outros 4
Port_1114738_0 | SOURCEANDSINK | Outros 4
Port_1114746_2 | SOURCEANDSINK | Outros 4
Port_1114738_1 | SOURCEANDSINK | Outros 4
Port_1114766_2 | SOURCEANDSINK | Outros 4
Port_1114748_0 | SOURCEANDSINK | Outros 4
Port_1114756_3 | SOURCEANDSINK | Outros 4
Port_1114748_1 | SOURCEANDSINK | Outros 4
Port_1114766_1 | SOURCEANDSINK | Outros 4
Port_1114756_1 | SOURCEANDSINK | Outros 4
Port_1114760_1 | SOURCEANDSINK | Outros 4
Port_1114756_2 | SOURCEANDSINK | Outros 4
Port_1114762_1 | SOURCEANDSINK | Outros 4
Port_1114757_1 | SOURCEANDSINK | Outros 4
Port_1114762_2 | SOURCEANDSINK | Outros 4
Port_1114773_0 | SOURCEANDSINK | Outros 6
Port_1114792_2 | SOURCEANDSINK | Outros 6
Port_1114773_1 | SOURCEANDSINK | Outros 6
Port_1114801_1 | SOURCEANDSINK | Outros 6
Port_1114784_2 | SOURCEANDSINK | Outros 6
Port_1114785_1 | SOURCEANDSINK | Outros 6
Port_1114784_3 | SOURCEANDSINK | Outros 6
Port_1114792_1 | SOURCEANDSINK | Outros 6
Port_1114795_0 | SOURCEANDSINK | Outros 6
Port_1114801_2 | SOURCEANDSINK | Outros 6
Port_1114795_1 | SOURCEANDSINK | Outros 6
Port_1114813_1 | SOURCEANDSINK | Outros 6
Port_1114803_0 | SOURCEANDSINK | Outros 6
Port_1114813_2 | SOURCEANDSINK | Outros 6
Port_1114803_1 | SOURCEANDSINK | Outros 6
Port_1114833_2 | SOURCEANDSINK | Outros 6
Port_1114815_0 | SOURCEANDSINK | Outros 6
Port_1114831_2 | SOURCEANDSINK | Outros 6
Port_1114815_1 | SOURCEANDSINK | Outros 6
Port_1114833_1 | SOURCEANDSINK | Outros 6
Port_1114823_2 | SOURCEANDSINK | Outros 6
Port_1114824_1 | SOURCEANDSINK | Outros 6
Port_1114823_3 | SOURCEANDSINK | Outros 6
Port_1114831_1 | SOURCEANDSINK | Outros 6
Port_1114973_2 | SOURCEANDSINK | Outros 6
Port_1114974_1 | SOURCEANDSINK | Outros 6
Port_1114973_3 | SOURCEANDSINK | Outros 6
Port_1115005_0 | SOURCEANDSINK | Outros 6
Port_1114993_0 | SOURCEANDSINK | Outros 6
Port_1115121_2 | SOURCEANDSINK | Outros 6
Port_1114993_1 | SOURCEANDSINK | Outros 6
Port_1115123_1 | SOURCEANDSINK | Outros 6
Port_1115004_1 | SOURCEANDSINK | Outros 6
Port_1115121_1 | SOURCEANDSINK | Outros 6
Port_1115004_2 | SOURCEANDSINK | Outros 6
Port_1115005_1 | SOURCEANDSINK | Outros 6
Port_1115004_3 | SOURCEANDSINK | Outros 6
Port_1115012_1 | SOURCEANDSINK | Outros 6
Port_1115053_0 | SOURCEANDSINK | Outros 4
Port_1115177_2 | SOURCEANDSINK | Outros 4
Port_1115053_1 | SOURCEANDSINK | Outros 4
Port_1115179_1 | SOURCEANDSINK | Outros 4
Port_1115065_1 | SOURCEANDSINK | Outros 4
Port_1115177_1 | SOURCEANDSINK | Outros 4
Port_1115065_2 | SOURCEANDSINK | Outros 4
Port_1115066_1 | SOURCEANDSINK | Outros 4
Port_1115065_3 | SOURCEANDSINK | Outros 4
Port_1115073_1 | SOURCEANDSINK | Outros 4
Port_1119237_0 | SOURCEANDSINK | Outros 7
Port_1119450_1 | SOURCEANDSINK | Outros 7
Port_1119237_1 | SOURCEANDSINK | Outros 7
Port_1119369_2 | SOURCEANDSINK | Outros 7
Port_1119359_0 | SOURCEANDSINK | Outros 7
Port_1119431_1 | SOURCEANDSINK | Outros 7
Port_1119359_1 | SOURCEANDSINK | Outros 7
Port_1119551_1 | SOURCEANDSINK | Outros 7
Port_1119369_1 | SOURCEANDSINK | Outros 7
Port_1119432_0 | SOURCEANDSINK | Outros 7
Port_1119393_0 | SOURCEANDSINK | Outros 7
Port_1119406_1 | SOURCEANDSINK | Outros 7
Port_1119393_1 | SOURCEANDSINK | Outros 7
Port_1119551_2 | SOURCEANDSINK | Outros 7
Port_1119400_0 | SOURCEANDSINK | Outros 7
Port_1119406_2 | SOURCEANDSINK | Outros 7
Port_1119400_1 | SOURCEANDSINK | Outros 7
Port_1119428_1 | SOURCEANDSINK | Fornecimento hidrônico 4
Port_1119431_3 | SOURCEANDSINK | Fornecimento hidrônico 4
Port_1119431_2 | SOURCEANDSINK | Outros 7
Port_1119432_1 | SOURCEANDSINK | Outros 7
Port_1119447_1 | SOURCEANDSINK | Fornecimento hidrônico 5
Port_1119450_3 | SOURCEANDSINK | Fornecimento hidrônico 5
Port_1119450_2 | SOURCEANDSINK | Outros 7
Port_1119451_0 | SOURCEANDSINK | Outros 7
Port_1119451_1 | SOURCEANDSINK | Outros 7
Port_1119496_1 | SOURCEANDSINK | Outros 7
Port_1119583_0 | SOURCEANDSINK | Outros 9
Port_1120288_1 | SOURCEANDSINK | Outros 9
Port_1119583_1 | SOURCEANDSINK | Outros 9
Port_1119780_1 | SOURCEANDSINK | Outros 9
Port_1119663_1 | SOURCEANDSINK | Fornecimento hidrônico 6
Port_1119666_3 | SOURCEANDSINK | Fornecimento hidrônico 6
Port_1119666_1 | SOURCEANDSINK | Outros 9
Port_1119721_0 | SOURCEANDSINK | Outros 9
Port_1119666_2 | SOURCEANDSINK | Outros 9
Port_1119667_1 | SOURCEANDSINK | Outros 9
Port_1119667_0 | SOURCEANDSINK | Outros 9
Port_1120022_1 | SOURCEANDSINK | Outros 9
Port_1119689_1 | SOURCEANDSINK | Fornecimento hidrônico 7
Port_1119705_0 | SOURCEANDSINK | Fornecimento hidrônico 7
Port_1119701_1 | SOURCEANDSINK | Fornecimento hidrônico 8
Port_1119704_3 | SOURCEANDSINK | Fornecimento hidrônico 8
Port_1119704_1 | SOURCEANDSINK | Outros 9
Port_1120086_0 | SOURCEANDSINK | Outros 9
Port_1119704_2 | SOURCEANDSINK | Outros 9
Port_1119705_1 | SOURCEANDSINK | Outros 9
Port_1119720_1 | SOURCEANDSINK | Outros 9
Port_1120289_0 | SOURCEANDSINK | Outros 9
Port_1119720_2 | SOURCEANDSINK | Outros 9
Port_1119721_1 | SOURCEANDSINK | Outros 9
Port_1119720_3 | SOURCEANDSINK | Outros 9
Port_1119737_0 | SOURCEANDSINK | Outros 9
Port_1119907_1 | SOURCEANDSINK | Outros 9
Port_1119737_1 | SOURCEANDSINK | Outros 9
Port_1119973_2 | SOURCEANDSINK | Outros 9
Port_1119780_2 | SOURCEANDSINK | Outros 9
Port_1119908_0 | SOURCEANDSINK | Outros 9
Port_1119904_1 | SOURCEANDSINK | Fornecimento hidrônico 10
Port_1119907_3 | SOURCEANDSINK | Fornecimento hidrônico 10
Port_1119907_2 | SOURCEANDSINK | Outros 9
Port_1119908_1 | SOURCEANDSINK | Outros 9
Port_1119918_0 | SOURCEANDSINK | Outros 9
Port_1119973_1 | SOURCEANDSINK | Outros 9
Port_1119918_1 | SOURCEANDSINK | Outros 9
Port_1119977_1 | SOURCEANDSINK | Outros 9
Port_1119942_0 | SOURCEANDSINK | Outros 9
Port_1119942_1 | SOURCEANDSINK | Outros 9
Port_1119977_2 | SOURCEANDSINK | Outros 9
Port_1119996_1 | SOURCEANDSINK | Fornecimento hidrônico 11
Port_1119999_3 | SOURCEANDSINK | Fornecimento hidrônico 11
Port_1119999_1 | SOURCEANDSINK | Outros 9
Port_1120023_0 | SOURCEANDSINK | Outros 9
Port_1119999_2 | SOURCEANDSINK | Outros 9
Port_1120000_1 | SOURCEANDSINK | Outros 9
Port_1120000_0 | SOURCEANDSINK | Outros 9
Port_1120085_1 | SOURCEANDSINK | Outros 9
Port_1120006_0 | SOURCEANDSINK | Outros 9
Port_1120006_1 | SOURCEANDSINK | Outros 9
Port_1120018_0 | SOURCEANDSINK | Outros 9
Port_1120022_3 | SOURCEANDSINK | Outros 9
Port_1120018_1 | SOURCEANDSINK | Outros 9
Port_1120026_1 | SOURCEANDSINK | Outros 9
Port_1120019_0 | SOURCEANDSINK | Outros 9
Port_1120026_2 | SOURCEANDSINK | Outros 9
Port_1120019_1 | SOURCEANDSINK | Outros 9
Port_1120022_2 | SOURCEANDSINK | Outros 9
Port_1120023_1 | SOURCEANDSINK | Outros 9
Port_1120061_1 | SOURCEANDSINK | Fornecimento hidrônico 12
Port_1120071_0 | SOURCEANDSINK | Outros 9
Port_1120201_2 | SOURCEANDSINK | Outros 9
Port_1120071_1 | SOURCEANDSINK | Outros 9
Port_1120273_1 | SOURCEANDSINK | Outros 9
Port_1120081_0 | SOURCEANDSINK | Outros 9
Port_1120085_3 | SOURCEANDSINK | Outros 9
Port_1120081_1 | SOURCEANDSINK | Outros 9
Port_1120089_1 | SOURCEANDSINK | Outros 9
Port_1120082_0 | SOURCEANDSINK | Outros 9
Port_1120089_2 | SOURCEANDSINK | Outros 9
Port_1120082_1 | SOURCEANDSINK | Outros 9
Port_1120201_1 | SOURCEANDSINK | Outros 9
Port_1120085_2 | SOURCEANDSINK | Outros 9
Port_1120086_1 | SOURCEANDSINK | Outros 9
Port_1120285_1 | SOURCEANDSINK | Fornecimento hidrônico 9
Port_1120288_3 | SOURCEANDSINK | Fornecimento hidrônico 9
Port_1120288_2 | SOURCEANDSINK | Outros 9
Port_1120289_1 | SOURCEANDSINK | Outros 9
Port_1120295_0 | SOURCEANDSINK | Outros 10
Port_1120502_1 | SOURCEANDSINK | Outros 10
Port_1120295_1 | SOURCEANDSINK | Outros 10
Port_1120458_1 | SOURCEANDSINK | Outros 10
Port_1120388_0 | SOURCEANDSINK | Outros 10
Port_1120458_2 | SOURCEANDSINK | Outros 10
Port_1120388_1 | SOURCEANDSINK | Outros 10
Port_1120462_1 | SOURCEANDSINK | Outros 10
Port_1120406_0 | SOURCEANDSINK | Outros 10
Port_1120421_1 | SOURCEANDSINK | Outros 10
Port_1120406_1 | SOURCEANDSINK | Outros 10
Port_1120462_2 | SOURCEANDSINK | Outros 10
Port_1120413_0 | SOURCEANDSINK | Outros 10
Port_1120421_2 | SOURCEANDSINK | Outros 10
Port_1120413_1 | SOURCEANDSINK | Outros 10
Port_1120481_1 | SOURCEANDSINK | Fornecimento hidrônico 14
Port_1120484_3 | SOURCEANDSINK | Fornecimento hidrônico 14
Port_1120484_1 | SOURCEANDSINK | Outros 10
Port_1120915_0 | SOURCEANDSINK | Outros 10
Port_1120484_2 | SOURCEANDSINK | Outros 10
Port_1120485_1 | SOURCEANDSINK | Outros 10
Port_1120485_0 | SOURCEANDSINK | Outros 10
Port_1120849_1 | SOURCEANDSINK | Outros 10
Port_1120499_1 | SOURCEANDSINK | Fornecimento hidrônico 15
Port_1120502_3 | SOURCEANDSINK | Fornecimento hidrônico 15
Port_1120502_2 | SOURCEANDSINK | Outros 10
Port_1120503_1 | SOURCEANDSINK | Outros 10
Port_1120503_0 | SOURCEANDSINK | Outros 10
Port_1120914_1 | SOURCEANDSINK | Outros 10

Properties of the parts of a building model (IFC2X3), part 5 of 5

# IfcFlowSegment: Tipos de tubos:Tubos de cobre HVAC (432)
Name (Tipos de tubos:Tubos de cobre HVAC:...) | In | Pset_DuctSegmentTypeCommon, Length (mm) = Pset_FlowSegmentDuctSegment, Length (mm) | Group
1088424 | Nível 1 | 1666.83 | Fornecimento hidrônico 2
1088466 | Nível 1 | 1180.58 | Fornecimento hidrônico 2
1088480 | Nível 1 | 95.7024 | Fornecimento hidrônico 2
1088534 | Nível 1 | 7122.04 | Outros 2
1088556 | Nível 1 | 3532.14 | Outros 2
1088726 | Nível 1 | 1303.67 | Outros 2
1088945 | Nível 1 | 1296.15 | Outros 2
1089003 | Nível 1 | 1296.15 | Outros 2
1089223 | Nível 1 | 1767.8 | Outros 2
1089313 | Nível 1 | 138.649 | Outros 2
1089314 | Nível 1 | 79.0011 | Outros 2
1089378 | Nível 1 | 7161.38 | Fornecimento hidrônico 2
1089387 | Nível 1 | 6040.07 | Fornecimento hidrônico 2
1089535 | Nível 1 | 3746.99 | Fornecimento hidrônico 2
1089582 | Nível 1 | 1614.73 | Fornecimento hidrônico 2
1089591 | Nível 1 | 94.4971 | Fornecimento hidrônico 2
1089594 | Nível 1 | 1611.56 | Fornecimento hidrônico 2
1089630 | Nível 1 | 3838.19 | Outros 2
1089779 | Nível 1 | 618.529 | Fornecimento hidrônico 2
1089895 | Nível 1 | 4637.91 | Fornecimento hidrônico 2
1090037 | Nível 1 | 3111.02 | Fornecimento hidrônico 1
1090095 | Nível 1 | 2909.43 | Fornecimento hidrônico 2
1090128 | Nível 1 | 8819 | Fornecimento hidrônico 1
1090168 | Nível 1 | 3.95809 | Fornecimento hidrônico 1
1090171 | Nível 1 | 1023.5 | Fornecimento hidrônico 1
1090188 | Nível 1 | 63.4588 | Fornecimento hidrônico 1
1090279 | Nível 1 | 8951.16 | Fornecimento hidrônico 2
1090293 | Nível 1 | 1552.89 | Fornecimento hidrônico 2
1090317 | Nível 1 | 1058.36 | Fornecimento hidrônico 1
1090333 | Nível 1 | 2389.42 | Fornecimento hidrônico 1
1090364 | Nível 1 | 1058.36 | Fornecimento hidrônico 1
1090473 | Nível 1 | 806.3 | Fornecimento hidrônico 2
1090517 | Nível 1 | 806.3 | Fornecimento hidrônico 2
1090535 | Nível 1 | 2130.18 | Fornecimento hidrônico 2
1090559 | Nível 1 | 1555.84 | Fornecimento hidrônico 2
1090603 | Nível 1 | 1558.41 | Fornecimento hidrônico 2
1090675 | Nível 1 | 1763.27 | Fornecimento hidrônico 1
1090715 | Nível 1 | 1763.27 | Fornecimento hidrônico 1
1090771 | Nível 1 | 1010.07 | Fornecimento hidrônico 1
1090793 | Nível 1 | 4174.71 | Fornecimento hidrônico 1
1090804 | Nível 1 | 18.9662 | Fornecimento hidrônico 1
1090807 | Nível 1 | 9588.77 | Fornecimento hidrônico 1
1090837 | Nível 1 | 658.632 | Fornecimento hidrônico 2
1090844 | Nível 1 | 59.0332 | Fornecimento hidrônico 2
1090847 | Nível 1 | 2699.22 | Fornecimento hidrônico 2
1090860 | Nível 1 | 166.678 | Fornecimento hidrônico 2
1090862 | Nível 1 | 2389.42 | Fornecimento hidrônico 1
1090870 | Nível 1 | 3625.09 | Fornecimento hidrônico 2
1090928 | Nível 1 | 66.1532 | Fornecimento hidrônico 2
1090931 | Nível 1 | 9309.63 | Fornecimento hidrônico 2
1090996 | Nível 1 | 352.787 | Fornecimento hidrônico 1
1091031 | Nível 1 | 4.25732 | Fornecimento hidrônico 1
1091034 | Nível 1 | 1685.69 | Fornecimento hidrônico 1
1091050 | Nível 1 | 63.4588 | Fornecimento hidrônico 1
1091252 | Nível 1 | 1434.64 | Fornecimento hidrônico 2
1091358 | Nível 1 | 9.94635 | Fornecimento hidrônico 1
1091361 | Nível 1 | 4818.97 | Fornecimento hidrônico 1
1091378 | Nível 1 | 63.4588 | Fornecimento hidrônico 1
1091505 | Nível 1 | 483.82 | Fornecimento hidrônico 2
1091520 | Nível 1 | 4865.22 | Fornecimento hidrônico 2
1091588 | Nível 1 | 2816.71 | Fornecimento hidrônico 1
1091670 | Nível 1 | 898.362 | Fornecimento hidrônico 1
1091682 | Nível 1 | 1304.92 | Fornecimento hidrônico 1
1091782 | Nível 1 | 898.362 | Fornecimento hidrônico 1
1091866 | Nível 1 | 805.921 | Fornecimento hidrônico 2
1091878 | Nível 1 | 1131.4 | Fornecimento hidrônico 2
1091918 | Nível 1 | 806.3 | Fornecimento hidrônico 2
1091931 | Nível 1 | 11.9365 | Fornecimento hidrônico 2
1091962 | Nível 1 | 2068.93 | Fornecimento hidrônico 1
1091973 | Nível 1 | 41.4592 | Fornecimento hidrônico 1
1091976 | Nível 1 | 650.387 | Fornecimento hidrônico 1
1091999 | Nível 1 | 3346.99 | Fornecimento hidrônico 2
1092011 | Nível 1 | 2269.58 | Fornecimento hidrônico 2
1092024 | Nível 1 | 32.8767 | Fornecimento hidrônico 2
1092027 | Nível 1 | 872.951 | Fornecimento hidrônico 2
1092237 | Nível 1 | 2207.36 | Fornecimento hidrônico 1
1092243 | Nível 1 | 3031.52 | Fornecimento hidrônico 1
1092311 | Nível 1 | 1885.88 | Fornecimento hidrônico 1
1092363 | Nível 1 | 658.363 | Fornecimento hidrônico 1
1092381 | Nível 1 | 244.977 | Fornecimento hidrônico 1
1092407 | Nível 1 | 658.363 | Fornecimento hidrônico 1
1092488 | Nível 1 | 466.3 | Fornecimento hidrônico 2
1092524 | Nível 1 | 466.3 | Fornecimento hidrônico 2
1092624 | Nível 1 | 2337.15 | Fornecimento hidrônico 1
1092633 | Nível 1 | 36.4189 | Fornecimento hidrônico 1
1092636 | Nível 1 | 2844.98 | Fornecimento hidrônico 1
1092740 | Nível 1 | 2278.04 | Fornecimento hidrônico 1
1092837 | Nível 1 | 3791.87 | Fornecimento hidrônico 1
1092852 | Nível 1 | 596.699 | Fornecimento hidrônico 1
1092906 | Nível 1 | 318.365 | Fornecimento hidrônico 1
1092956 | Nível 1 | 45.1215 | Fornecimento hidrônico 1
1093016 | Nível 1 | 256.042 | Fornecimento hidrônico 1
1093027 | Nível 1 | 122.897 | Fornecimento hidrônico 1
1093030 | Nível 1 | 635.499 | Fornecimento hidrônico 1
1093043 | Nível 1 | 3642.04 | Fornecimento hidrônico 1
1093286 | Nível 1 | 1313.25 | Fornecimento hidrônico 2
1093295 | Nível 1 | 2130.69 | Fornecimento hidrônico 2
1093307 | Nível 1 | 61.7544 | Fornecimento hidrônico 2
1093309 | Nível 1 | 2540.18 | Fornecimento hidrônico 1
1093317 | Nível 1 | 2232.14 | Fornecimento hidrônico 2
1093325 | Nível 1 | 3389 | Fornecimento hidrônico 2
1093695 | Nível 1 | 37.082 | Fornecimento hidrônico 2
1093702 | Nível 1 | 639.202 | Fornecimento hidrônico 2
1093715 | Nível 1 | 38.3805 | Fornecimento hidrônico 2
1093718 | Nível 1 | 2137.81 | Fornecimento hidrônico 2
1093824 | Nível 1 | 2166.3 | Fornecimento hidrônico 2
1093836 | Nível 1 | 365.785 | Fornecimento hidrônico 2
1093844 | Nível 1 | 388.254 | Fornecimento hidrônico 2
1093958 | Nível 1 | 1414.42 | Fornecimento hidrônico 2
1094306 | Nível 1 | 2087.69 | Fornecimento hidrônico 2
1094308 | Nível 1 | 3238.11 | Fornecimento hidrônico 2
1094632 | Nível 1 | 552.812 | Fornecimento hidrônico 2
1094750 | Nível 1 | 51.9488 | Fornecimento hidrônico 2
1094826 | Nível 1 | 289.567 | Fornecimento hidrônico 2
1094866 | Nível 1 | 130.043 | Fornecimento hidrônico 2
1094876 | Nível 1 | 2592.81 | Fornecimento hidrônico 2
1094880 | Nível 1 | 367.611 | Fornecimento hidrônico 2
1094925 | Nível 1 | 51.9488 | Fornecimento hidrônico 2
1094956 | Nível 1 | 2366.3 | Fornecimento hidrônico 2
1094978 | Nível 1 | 483.29 | Fornecimento hidrônico 2
1094990 | Nível 1 | 378.352 | Fornecimento hidrônico 2
1095001 | Nível 1 | 51.9488 | Fornecimento hidrônico 2
1095094 | Nível 1 | 558.363 | Fornecimento hidrônico 1
1095166 | Nível 1 | 458.326 | Fornecimento hidrônico 1
1095180 | Nível 1 | 693.832 | Fornecimento hidrônico 1
1095201 | Nível 1 | 666.3 | Fornecimento hidrônico 1
1095255 | Nível 1 | 300.066 | Fornecimento hidrônico 1
1095269 | Nível 1 | 837.54 | Fornecimento hidrônico 1
1095288 | Nível 1 | 355.868 | Fornecimento hidrônico 1
1095308 | Nível 1 | 2037.08 | Fornecimento hidrônico 1
1095318 | Nível 1 | 3237.08 | Fornecimento hidrônico 1
1095326 | Nível 1 | 847.163 | Fornecimento hidrônico 1
1095354 | Nível 1 | 494.602 | Fornecimento hidrônico 1
1095442 | Nível 1 | 246.3 | Fornecimento hidrônico 1
1095460 | Nível 1 | 2251.95 | Fornecimento hidrônico 1
1095472 | Nível 1 | 3151.95 | Fornecimento hidrônico 1
1095506 | Nível 1 | 285.034 | Fornecimento hidrônico 1
1095518 | Nível 1 | 1183.87 | Fornecimento hidrônico 1
1095543 | Nível 1 | 1410.32 | Fornecimento hidrônico 1
1095573 | Nível 1 | 6373.42 | Fornecimento hidrônico 1
1095581 | Nível 1 | 3017.27 | Fornecimento hidrônico 1
1095591 | Nível 1 | 5922.11 | Fornecimento hidrônico 1
1095615 | Nível 1 | 637.666 | Fornecimento hidrônico 2
1095645 | Nível 1 | 7113.06 | Fornecimento hidrônico 1
1095653 | Nível 1 | 3042.04 | Fornecimento hidrônico 1
1095663 | Nível 1 | 2572.23 | Fornecimento hidrônico 1
1095681 | Nível 1 | 1167.18 | Fornecimento hidrônico 1
1095708 | Nível 1 | 2158.55 | Fornecimento hidrônico 1
1095783 | Nível 1 | 2687.18 | Fornecimento hidrônico 1
1095804 | Nível 1 | 27.176 | Fornecimento hidrônico 1
1095811 | Nível 1 | 273.024 | Fornecimento hidrônico 1
1095824 | Nível 1 | 28.284 | Fornecimento hidrônico 1
1095827 | Nível 1 | 4312.36 | Fornecimento hidrônico 1
1095912 | Nível 1 | 22.029 | Fornecimento hidrônico 1
1095919 | Nível 1 | 80.7213 | Fornecimento hidrônico 1
1095953 | Nível 1 | 646.138 | Fornecimento hidrônico 1
1095964 | Nível 1 | 1548.35 | Fornecimento hidrônico 1
1095967 | Nível 1 | 2499.22 | Fornecimento hidrônico 1
1095978 | Nível 1 | 3005.01 | Fornecimento hidrônico 1
1096038 | Nível 1 | 2146.99 | Fornecimento hidrônico 1
1096048 | Nível 1 | 2646.28 | Fornecimento hidrônico 1
1096057 | Nível 1 | 1221.21 | Fornecimento hidrônico 1
1096075 | Nível 1 | 112.962 | Fornecimento hidrônico 1
1096086 | Nível 1 | 2027.18 | Fornecimento hidrônico 1
1096096 | Nível 1 | 1064.09 | Fornecimento hidrônico 1
1096108 | Nível 1 | 38.8402 | Fornecimento hidrônico 1
1096111 | Nível 1 | 1694.29 | Fornecimento hidrônico 1
1096328 | Nível 1 | 142.043 | Fornecimento hidrônico 1
1096335 | Nível 1 | 6121.02 | Fornecimento hidrônico 2
1096349 | Nível 1 | 1640.79 | Fornecimento hidrônico 1
1096537 | Nível 1 | 142.043 | Fornecimento hidrônico 2
1096544 | Nível 1 | 4.78184 | Fornecimento hidrônico 2
1096669 | Nível 1 | 6432.27 | Fornecimento hidrônico 1
1096683 | Nível 1 | 2727.98 | Fornecimento hidrônico 1
1096760 | Nível 1 | 114.849 | Fornecimento hidrônico 1
1096767 | Nível 1 | 116.238 | Fornecimento hidrônico 1
1096908 | Nível 1 | 1947 | Fornecimento hidrônico 1
1096919 | Nível 1 | 9207 | Fornecimento hidrônico 1
1096933 | Nível 1 | 2564.16 | Fornecimento hidrônico 1
1097026 | Nível 1 | 2108.77 | Fornecimento hidrônico 2
1097036 | Nível 1 | 9275.75 | Fornecimento hidrônico 2
1097046 | Nível 1 | 2844.94 | Fornecimento hidrônico 2
1097181 | Nível 1 | 98.3069 | Fornecimento hidrônico 2
1097184 | Nível 1 | 2274.35 | Fornecimento hidrônico 2
1097226 | Nível 1 | 2513.41 | Outros 2
1097322 | Nível 1 | 565.519 | Outros 2
1097338 | Nível 1 | 17.27 | Outros 2
1097476 | Nível 1 | 188.599 | Outros 2
1097492 | Nível 1 | 47.3187 | Outros 2
1097493 | Nível 1 | 55.2672 | Outros 2
1097497 | Nível 1 | 2216.89 | Fornecimento hidrônico 1
1098315 | Nível 1 | 51.507 | Fornecimento hidrônico 2
1098322 | Nível 1 | 103.09 | Fornecimento hidrônico 2
1098335 | Nível 1 | 32.1368 | Fornecimento hidrônico 2
1098375 | Nível 1 | 63.4588 | Fornecimento hidrônico 1
1098578 | Nível 1 | 217.27 | Fornecimento hidrônico 1
1098585 | Nível 1 | 132.27 | Fornecimento hidrônico 1
1098992 | Nível 1 | 217.27 | Fornecimento hidrônico 1
1099078 | Nível 1 | 1432.27 | Fornecimento hidrônico 1
1099262 | Nível 1 | 117.27 | Fornecimento hidrônico 1
1100212 | Nível 2 | 668.69 | Outros 3
1100224 | Nível 2 | 357.38 | Outros 3
1100242 | Nível 2 | 1406.07 | Outros 3
1100434 | Nível 2 | 1184.37 | Outros 3
1100473 | Nível 2 | 251.092 | Outros 3
1100593 | Nível 2 | 430.434 | Fornecimento hidrônico 2
1100610 | Nível 2 | 252.137 | Fornecimento hidrônico 2
1100620 | Nível 2 | 1132.14 | Fornecimento hidrônico 2
1100628 | Nível 2 | 1225.12 | Fornecimento hidrônico 2
1100651 | Nível 2 | 272.316 | Fornecimento hidrônico 2
1100993 | Nível 1 | 46.9795 | Fornecimento hidrônico 2
1101003 | Nível 1 | 13.2202 | Fornecimento hidrônico 2
1101016 | Nível 1 | 46.9795 | Fornecimento hidrônico 2
1101887 | Nível 2 | 667.057 | Outros 3
1102004 | Nível 2 | 759.307 | Fornecimento hidrônico 2
1102323 | Nível 1 | 34.8354 | Fornecimento hidrônico 2
1102326 | Nível 1 | 2978.29 | Fornecimento hidrônico 2
1102648 | Nível 1 | 1723.06 | Fornecimento hidrônico 1
1102665 | Nível 1 | 1723.06 | Fornecimento hidrônico 1
1103798 | Nível 2 | 1003.78 | Outros 4
1103812 | Nível 2 | 4987.55 | Outros 4
1103831 | Nível 2 | 3100.95 | Outros 4
1103971 | Nível 2 | 658.363 | Outros 5
1103987 | Nível 2 | 1813.63 | Outros 5
1104020 | Nível 2 | 658.363 | Outros 5
1104102 | Nível 2 | 421.3 | Outros 6
1104118 | Nível 2 | 1959.98 | Outros 6
1104151 | Nível 2 | 421.3 | Outros 6
1104322 | Nível 2 | 1103.59 | Retorno hidrônico 1
1104334 | Nível 2 | 5087.18 | Retorno hidrônico 1
1104354 | Nível 2 | 2999.38 | Retorno hidrônico 1
1104497 | Nível 2 | 712.521 | Retorno hidrônico 2
1104516 | Nível 2 | 190.689 | Retorno hidrônico 2
1104519 | Nível 2 | 1733.63 | Outros 5
1104532 | Nível 2 | 2280.94 | Retorno hidrônico 2
1104560 | Nível 2 | 711.021 | Outros 4
1104639 | Nível 2 | 2627.09 | Outros 4
1104671 | Nível 2 | 698.348 | Outros 4
1104855 | Nível 2 | 446.3 | Outros 6
1104867 | Nível 2 | 3140.49 | Outros 6
1104893 | Nível 2 | 446.3 | Outros 6
1104987 | Nível 2 | 1342.51 | Outros 4
1104996 | Nível 2 | 2627.09 | Outros 4
1105051 | Nível 2 | 1553.21 | Outros 6
1105060 | Nível 2 | 2133.83 | Outros 6
1105089 | Nível 2 | 2113.78 | Outros 4
1105108 | Nível 2 | 7966.32 | Outros 4
1105128 | Nível 2 | 2059.71 | Outros 6
1105141 | Nível 2 | 7489.09 | Outros 6
1105172 | Nível 2 | 2108.01 | Outros 4
1105192 | Nível 2 | 5261.62 | Outros 4
1105212 | Nível 2 | 2047.23 | Outros 6
1105236 | Nível 2 | 5298.96 | Outros 6
1105318 | Nível 2 | 2108.01 | Outros 4
1105331 | Nível 2 | 4992.62 | Outros 4
1105351 | Nível 2 | 2044.9 | Outros 6
1105367 | Nível 2 | 5030.87 | Outros 6
1105482 | Nível 2 | 168.187 | Retorno hidrônico 2
1105485 | Nível 2 | 1070.27 | Outros 4
1105517 | Nível 2 | 856.618 | Outros 6
1105526 | Nível 2 | 1637.83 | Outros 6
1105529 | Nível 2 | 2047.95 | Outros 6
1105540 | Nível 2 | 1419.84 | Outros 6
1105683 | Nível 2 | 518.362 | Outros 4
1105725 | Nível 2 | 518.362 | Outros 4
1105782 | Nível 2 | 326.3 | Outros 6
1105822 | Nível 2 | 326.3 | Outros 6
1106003 | Nível 2 | 2099.36 | Outros 4
1106014 | Nível 2 | 1364.16 | Outros 4
1106033 | Nível 2 | 1120.98 | Outros 4
1106043 | Nível 2 | 1364.16 | Outros 4
1106053 | Nível 2 | 1809.77 | Outros 6
1106157 | Nível 2 | 1164.03 | Outros 6
1106219 | Nível 2 | 1614.86 | Outros 6
1106223 | Nível 2 | 802.47 | Outros 6
1106299 | Nível 2 | 151.021 | Outros 4
1106396 | Nível 2 | 12.0342 | Outros 4
1106403 | Nível 2 | 1416.54 | Outros 4
1106424 | Nível 2 | 9563.62 | Outros 4
1106460 | Nível 2 | 1525.21 | Outros 6
1106481 | Nível 2 | 9770 | Outros 6
1106658 | Nível 2 | 383.363 | Outros 8
1106753 | Nível 2 | 2059.62 | Outros 8
1106779 | Nível 2 | 383.362 | Outros 8
1106848 | Nível 2 | 205.921 | Outros 6
1106951 | Nível 2 | 196.251 | Outros 6
1107138 | Nível 2 | 2851.12 | Outros 4
1107150 | Nível 2 | 2059.62 | Outros 8
1107167 | Nível 2 | 8864.37 | Outros 4
1107244 | Nível 2 | 2936.83 | Outros 6
1107361 | Nível 2 | 2784.07 | Outros 6
1107405 | Nível 2 | 1349.11 | Outros 6
1107415 | Nível 2 | 8187.37 | Outros 6
1107456 | Nível 2 | 458.363 | Outros 4
1107472 | Nível 2 | 700.046 | Outros 4
1107500 | Nível 2 | 458.363 | Outros 4
1107589 | Nível 2 | 186.3 | Outros 6
1107603 | Nível 2 | 897.761 | Outros 6
1107635 | Nível 2 | 186.3 | Outros 6
1107694 | Nível 2 | 418.362 | Outros 4
1107710 | Nível 2 | 798.387 | Outros 4
1107738 | Nível 2 | 418.362 | Outros 4
1107865 | Nível 2 | 226.3 | Outros 6
1107877 | Nível 2 | 553.206 | Outros 6
1107905 | Nível 2 | 226.3 | Outros 6
1108003 | Nível 2 | 264.469 | Outros 4
1108065 | Nível 2 | 263.168 | Outros 6
1108118 | Nível 2 | 229.689 | Outros 4
1108129 | Nível 2 | 700.046 | Outros 4
1108138 | Nível 2 | 2190.27 | Outros 4
1108152 | Nível 2 | 2739.23 | Outros 4
1108176 | Nível 2 | 348.773 | Outros 6
1108183 | Nível 2 | 552.898 | Outros 6
1108186 | Nível 2 | 1800.97 | Outros 6
1108199 | Nível 2 | 2959.85 | Outros 6
1108240 | Nível 2 | 1806.99 | Outros 6
1108250 | Nível 2 | 1361.58 | Outros 6
1108259 | Nível 2 | 897.453 | Outros 6
1108271 | Nível 2 | 2112.14 | Outros 4
1108281 | Nível 2 | 1311.98 | Outros 4
1108290 | Nível 2 | 601.705 | Outros 4
1108380 | Nível 2 | 3573.99 | Outros 4
1108430 | Nível 2 | 2618.13 | Outros 4
1108615 | Nível 2 | 3615.73 | Outros 6
1108754 | Nível 2 | 1822.97 | Outros 4
1108765 | Nível 2 | 13.4514 | Outros 4
1108768 | Nível 2 | 5441.77 | Outros 4
1108776 | Nível 2 | 1468.94 | Outros 4
1108837 | Nível 2 | 2001.26 | Outros 6
1108888 | Nível 2 | 3403.51 | Outros 6
1108923 | Nível 2 | 3106.42 | Outros 6
1108933 | Nível 2 | 4640.75 | Outros 6
1108937 | Nível 2 | 1266.93 | Outros 6
1109175 | Nível 2 | 42.5819 | Outros 6
1109182 | Nível 2 | 637.082 | Outros 6
1109917 | Nível 2 | 4017.27 | Outros 4
1109927 | Nível 2 | 1417.27 | Outros 4
1109935 | Nível 2 | 506.38 | Outros 4
1109946 | Nível 2 | 1835.25 | Outros 4
1109994 | Nível 2 | 3842.04 | Outros 6
1110004 | Nível 2 | 1642.04 | Outros 6
1110012 | Nível 2 | 839.796 | Outros 6
1110023 | Nível 2 | 2040.06 | Outros 6
1110150 | Nível 2 | 558.363 | Outros 4
1110196 | Nível 2 | 558.363 | Outros 4
1110267 | Nível 2 | 406.3 | Outros 6
1110307 | Nível 2 | 406.3 | Outros 6
1110332 | Nível 2 | 309.689 | Outros 4
1110348 | Nível 2 | 1148.76 | Outros 4
1110415 | Nível 2 | 1148.76 | Outros 4
1110429 | Nível 2 | 1894.64 | Outros 4
1110526 | Nível 2 | 3032.14 | Outros 4
1110555 | Nível 2 | 6329.8 | Outros 4
1110563 | Nível 2 | 275.109 | Outros 4
1110664 | Nível 2 | 1956.75 | Outros 6
1110708 | Nível 2 | 653.095 | Outros 6
1110732 | Nível 2 | 180.657 | Outros 6
1110824 | Nível 2 | 1032.97 | Outros 6
1110830 | Nível 2 | 1315.12 | Outros 6
1110896 | Nível 2 | 2891.95 | Outros 6
1110922 | Nível 2 | 1875.57 | Outros 4
1111020 | Nível 2 | 1764.28 | Outros 6
1111174 | Nível 2 | 1032.14 | Outros 4
1111182 | Nível 2 | 385.418 | Outros 4
1111202 | Nível 2 | 248.69 | Outros 4
1111288 | Nível 2 | 22.6469 | Outros 6
1111291 | Nível 2 | 6492.29 | Outros 6
1111348 | Nível 2 | 551.949 | Outros 6
1111360 | Nível 2 | 131.949 | Outros 6
1111370 | Nível 2 | 671.949 | Outros 6
1111378 | Nível 2 | 261.357 | Outros 6
1111394 | Nível 2 | 14.8066 | Outros 6
1111395 | Nível 2 | 50.9946 | Outros 6
1111399 | Nível 2 | 691.915 | Outros 6
1111463 | Nível 2 | 5479.46 | Outros 4
1111510 | Nível 2 | 5729.58 | Outros 6
1111793 | Nível 2 | 2807.15 | Outros 4
1111805 | Nível 2 | 937.776 | Outros 4
1111834 | Nível 2 | 2954.92 | Outros 6; Retorno hidrônico 1
1111847 | Nível 2 | 764.959 | Retorno hidrônico 1
1112905 | Nível 2 | 558.362 | Outros 4
1112923 | Nível 2 | 1121.08 | Outros 4
1112954 | Nível 2 | 592.108 | Outros 4
1112979 | Nível 2 | 386.3 | Outros 6
1112991 | Nível 2 | 1296.41 | Outros 6
1113019 | Nível 2 | 419.666 | Outros 6
1113082 | Nível 2 | 432.268 | Outros 4
1113096 | Nível 2 | 1121.08 | Outros 4
1113241 | Nível 2 | 758.363 | Outros 4
1113263 | Nível 2 | 815.647 | Outros 4
1113313 | Nível 2 | 4373.67 | Outros 4
1113407 | Nível 2 | 1320.38 | Outros 4
1113451 | Nível 2 | 474.064 | Outros 4
1113522 | Nível 2 | 1186.25 | Outros 6
1113550 | Nível 2 | 438.52 | Outros 6
1113666 | Nível 2 | 2203.76 | Outros 4
1113862 | Nível 2 | 816.618 | Outros 6
1113869 | Nível 2 | 996.483 | Outros 6
1113928 | Nível 2 | 170.253 | Outros 6
1113933 | Nível 2 | 4466.92 | Outros 6
1113986 | Nível 2 | 2144.33 | Outros 6
1114077 | Nível 2 | 846.3 | Outros 6
1114091 | Nível 2 | 737.655 | Outros 6
1114710 | Nível 2 | 3585.78 | Outros 4
1114721 | Nível 2 | 1070.27 | Outros 4
1114730 | Nível 2 | 25032.1 | Outros 4
1114738 | Nível 2 | 2232.14 | Outros 4
1114748 | Nível 2 | 1055.74 | Outros 4
1114757 | Nível 2 | 732.814 | Outros 4
1114773 | Nível 2 | 3229.6 | Outros 6
1114785 | Nível 2 | 936.104 | Outros 6
1114795 | Nível 2 | 24547 | Outros 6
1114803 | Nível 2 | 2246.99 | Outros 6
1114815 | Nível 2 | 1399.72 | Outros 6
1114824 | Nível 2 | 1059.63 | Outros 6
1114974 | Nível 2 | 45.0105 | Outros 6
1114993 | Nível 2 | 418.836 | Outros 6
1115005 | Nível 2 | 1919.17 | Outros 6
1115053 | Nível 2 | 289.419 | Outros 4
1115066 | Nível 2 | 5158.12 | Outros 4

# IfcFlowSegment: Tubulação flexível redonda:Flexível - Redondo (45)
Type - PredefinedType: FLEXIBLESEGMENT
Pset_DistributionFlowElementCommon - Reference: Flexível - Redondo; sets with these values: 2
Name (Tubulação flexível redonda:Flexível - Redondo:...) | In | Group
1119428 | Nível 1 | Fornecimento hidrônico 4
1119447 | Nível 1 | Fornecimento hidrônico 5
1119496 | Nível 1 | Fornecimento hidrônico 3; Outros 7
1119663 | Nível 1 | Fornecimento hidrônico 6
1119689 | Nível 1 | Fornecimento hidrônico 7
1119701 | Nível 1 | Fornecimento hidrônico 8
1119904 | Nível 1 | Fornecimento hidrônico 10
1119996 | Nível 1 | Fornecimento hidrônico 11
1120061 | Nível 1 | Fornecimento hidrônico 12
1120273 | Nível 1 | Fornecimento hidrônico 13; Outros 9
1120285 | Nível 1 | Fornecimento hidrônico 9
1120481 | Nível 1 | Fornecimento hidrônico 14
1120499 | Nível 1 | Fornecimento hidrônico 15
1120517 | Nível 1 | Fornecimento hidrônico 16
1120633 | Nível 1 | Fornecimento hidrônico 17; Outros 10
1120645 | Nível 1 | Fornecimento hidrônico 18
1120899 | Nível 1 | Fornecimento hidrônico 19; Outros 10
1120963 | Nível 1 | Fornecimento hidrônico 20; Outros 10
1121035 | Nível 1 | Fornecimento hidrônico 21; Outros 10
1122579 | Nível 2 | Fornecimento hidrônico 22
1122597 | Nível 2 | Fornecimento hidrônico 23
1122699 | Nível 2 | Fornecimento hidrônico 24
1122717 | Nível 2 | Fornecimento hidrônico 25
1122735 | Nível 2 | Fornecimento hidrônico 26
1122747 | Nível 2 | Fornecimento hidrônico 27
1122763 | Nível 2 | Fornecimento hidrônico 28
1123230 | Nível 2 | Fornecimento hidrônico 29; Outros 12
1123242 | Nível 2 | Fornecimento hidrônico 30
1123266 | Nível 2 | Fornecimento hidrônico 31
1123286 | Nível 2 | Fornecimento hidrônico 32
1123306 | Nível 2 | Fornecimento hidrônico 33
1123324 | Nível 2 | Fornecimento hidrônico 34
1123346 | Nível 2 | Fornecimento hidrônico 35
1123366 | Nível 2 | Fornecimento hidrônico 36
1123384 | Nível 2 | Fornecimento hidrônico 37
1123402 | Nível 2 | Fornecimento hidrônico 38
1123420 | Nível 2 | Fornecimento hidrônico 39
1123491 | Nível 2 | Fornecimento hidrônico 40
1123509 | Nível 2 | Fornecimento hidrônico 41
1123732 | Nível 2 | Fornecimento hidrônico 42
1123750 | Nível 2 | Fornecimento hidrônico 43
1123873 | Nível 2 | Fornecimento hidrônico 44; Outros 13
1124075 | Nível 2 | Fornecimento hidrônico 45; Outros 12
1124087 | Nível 2 | Fornecimento hidrônico 46
1124107 | Nível 2 | Fornecimento hidrônico 47

# IfcFlowTerminal: 11 - Difusor Quadrado:SDQ3535 (8)
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Sicflux
Pset_DistributionFlowElementCommon - Reference: SDQ3535; sets with these values: 2
Name (11 - Difusor Quadrado:SDQ3535:...) | In | Group
1002486 | Nível 1 | Mecânica Ar de fornecimento 12
1002505 | Nível 1 | Mecânica Ar de fornecimento 12
1002516 | Nível 1 | Mecânica Ar de fornecimento 12
1002547 | Nível 1 | Mecânica Ar de fornecimento 11
1002562 | Nível 1 | Mecânica Ar de fornecimento 11
1002581 | Nível 1 | Mecânica Ar de fornecimento 11
1008020 | Nível 2 | Mecânica Ar de fornecimento 17
1008035 | Nível 2 | Mecânica Ar de fornecimento 14

# IfcFlowTerminal: M_Difusor de fornecimento:600 x 600 Face 300 x 300 Conexão (21)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 600 x 600 Face 300 x 300 Conexão; sets with these values: 2
Name (M_Difusor de fornecimento:600 x 600 Face 300 x 300 Conexão:...) | In | Group
997985 | Nível 1 | Mecânica Ar de fornecimento 1
998008 | Nível 1 | Mecânica Ar de fornecimento 1
998015 | Nível 1 | Mecânica Ar de fornecimento 1
998045 | Nível 1 | Mecânica Ar de fornecimento 1
998068 | Nível 1 | Mecânica Ar de fornecimento 1
998083 | Nível 1 | Mecânica Ar de fornecimento 1
998113 | Nível 1 | Mecânica Ar de fornecimento 1
998124 | Nível 1 | Mecânica Ar de fornecimento 1
1001901 | Nível 1 | Mecânica Ar de fornecimento 9
1001916 | Nível 1 | Mecânica Ar de fornecimento 9
1001935 | Nível 1 | Mecânica Ar de fornecimento 9
1003574 | Nível 2 | Mecânica Ar de fornecimento 13
1003612 | Nível 2 | Mecânica Ar de fornecimento 13
1003631 | Nível 2 | Mecânica Ar de fornecimento 13
1004613 | Nível 2 | Mecânica Ar de fornecimento 13
1004658 | Nível 2 | Mecânica Ar de fornecimento 13
1004673 | Nível 2 | Mecânica Ar de fornecimento 13
1004688 | Nível 2 | Mecânica Ar de fornecimento 13
1007462 | Nível 2 | Mecânica Ar de fornecimento 17
1007471 | Nível 2 | Mecânica Ar de fornecimento 17
1008121 | Nível 2 | Mecânica Ar de fornecimento 17

# IfcFlowTerminal: M_Difusor de retorno:600 x 600 Face 300 x 300 Conexão (24)
Type - Material: <Unnamed>
Pset_DistributionFlowElementCommon - Reference: 600 x 600 Face 300 x 300 Conexão; sets with these values: 2
Name (M_Difusor de retorno:600 x 600 Face 300 x 300 Conexão:...) | In | Group
998212 | Nível 1 | Mecânica Ar de fornecimento 3
998234 | Nível 1 | Mecânica Ar de fornecimento 3
998245 | Nível 1 | Mecânica Ar de fornecimento 3
998271 | Nível 1 | Mecânica Ar de fornecimento 3
998294 | Nível 1 | Mecânica Ar de fornecimento 4
998309 | Nível 1 | Mecânica Ar de fornecimento 4
998339 | Nível 1 | Mecânica Ar de fornecimento 4
998361 | Nível 1 | Mecânica Ar de fornecimento 4
998959 | Nível 1 | Mecânica Ar de fornecimento 3
998971 | Nível 1 | Mecânica Ar de fornecimento 3
998990 | Nível 1 | Mecânica Ar de fornecimento 4
999005 | Nível 1 | Mecânica Ar de fornecimento 4
1001825 | Nível 1 | Mecânica Ar de fornecimento 10
1001832 | Nível 1 | Mecânica Ar de fornecimento 10
1001847 | Nível 1 | Mecânica Ar de fornecimento 10
1003814 | Nível 2 | Mecânica Ar de fornecimento 14
1003843 | Nível 2 | Mecânica Ar de fornecimento 14
1003858 | Nível 2 | Mecânica Ar de fornecimento 14
1005938 | Nível 2 | Mecânica Ar de fornecimento 14
1006228 | Nível 2 | Mecânica Ar de fornecimento 14
1006237 | Nível 2 | Mecânica Ar de fornecimento 14
1007603 | Nível 2 | Mecânica Ar de fornecimento 14
1007618 | Nível 2 | Mecânica Ar de fornecimento 14
1008083 | Nível 2 | Mecânica Ar de fornecimento 14
